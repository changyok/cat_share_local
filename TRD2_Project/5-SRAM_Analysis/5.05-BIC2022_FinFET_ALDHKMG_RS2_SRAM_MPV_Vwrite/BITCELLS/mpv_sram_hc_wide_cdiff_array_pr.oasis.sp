*|TITLE Netlist generated by Raphael FX rcnetmerge
*|TITLE 1.1
*|TITLE Date Fri Apr 23 15:37:34 PDT 2021
*|PARAM cellnamefrom= raphaelfx
*|PARAM include= {}
*|PARAM instancefrom= raphaelnet
*|PARAM outputnet= n940_rph.spf
*|PARAM pingroup=  WL {WLL WLR} BL {BLU BLD} BLB {BLBU BLBD}
*|PARAM pinsfrom= raphaelfx
*|PARAM raphaelnet= n940_rph.spi
*|PARAM referencenet= /nfs/pdx/disks/icf_sandp_gwa001/changyok/swb/SNPS_DTCO/TRD2/20201220/BIC2022_update20210412/2-RC_Extraction/2.01-BIC2022_FinFET_PEX_Nominal/sram_hc_wide.lvs

.SUBCKT array BLBD BLBU BLD BLU VDD VSS WLL WLR VBP VBN

*|NETS BL BLB VDD VSS WL iQ1 iQ2

*|CAPACITANCE GRAND SUM 2.9665e-04PF
*|BLB WL 2.3946e-05PF
*|BLB iQ1 8.5392e-07PF
*|BLB iQ2 5.9512e-06PF
*|BL BLB 1.2597e-07PF
*|BL WL 2.4035e-05PF
*|BL iQ1 6.0223e-06PF
*|BL iQ2 8.5423e-07PF
*|VDD BL 8.7454e-06PF
*|VDD BLB 8.7089e-06PF
*|VDD VSS 1.1414e-05PF
*|VDD WL 8.2378e-06PF
*|VDD iQ1 1.4517e-05PF
*|VDD iQ2 1.4526e-05PF
*|VSS BL 8.7961e-06PF
*|VSS BLB 9.1010e-06PF
*|VSS WL 2.6127e-05PF
*|VSS iQ1 1.5677e-05PF
*|VSS iQ2 1.5681e-05PF
*|WL iQ1 2.1840e-05PF
*|WL iQ2 2.1519e-05PF
*|iQ1 iQ2 4.9967e-05PF

*|NET BL 4.8579e-05PF
C_0_0 BLBD BLD 7.6364e-22
C_0_1 BLBD BLU 7.6364e-22
C_0_2 BLBD BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 1.3777e-21
C_0_3 BLBD BL:LM00Cobalt2XG535UTiSiXG524X1 6.2116e-22
C_0_4 BLBD BL:SiliconNXG516UTiSiXG524X1 1.5275e-22
C_0_5 BLBD BL:n2d 2.7282e-22
C_0_6 BLBU BLD 7.6364e-22
C_0_7 BLBU BLU 7.6364e-22
C_0_8 BLBU BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 1.3777e-21
C_0_9 BLBU BL:LM00Cobalt2XG535UTiSiXG524X1 6.2116e-22
C_0_10 BLBU BL:SiliconNXG516UTiSiXG524X1 1.5275e-22
C_0_11 BLBU BL:n2d 2.7282e-22
C_0_12 BLD WLL 3.6147e-19
C_0_13 BLD WLR 3.6147e-19
C_0_14 BLD BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 1.3609e-21
C_0_15 BLD BLB:LM00Cobalt2XG71UTiSiXG73X1 6.0485e-22
C_0_16 BLD BLB:SiliconNXG72UTiSiXG73X1 1.5984e-22
C_0_17 BLD BLB:n3s 2.8186e-22
C_0_18 BLD WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.5821e-22
C_0_19 BLD WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.5817e-23
C_0_20 BLD WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.5371e-19
C_0_21 BLD WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 8.1812e-19
C_0_22 BLD WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 5.0530e-19
C_0_23 BLD WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 9.1292e-19
C_0_24 BLD WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 3.6147e-19
C_0_25 BLD WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.5897e-23
C_0_26 BLD WL:n2g 7.2280e-22
C_0_27 BLD WL:n3g 3.9718e-23
C_0_28 BLD iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 2.3695e-19
C_0_29 BLD iQ1:LM00Cobalt2XG308USiGeBXG285X1 2.1612e-19
C_0_30 BLD iQ1:LM00Cobalt2XG308UTiSiXG295X1 2.1612e-19
C_0_31 BLD iQ1:LM00Cobalt2XG308UTiSiXG296X1 2.1611e-19
C_0_32 BLD iQ1:SDexcludeXG264UTiSiXG296X1 5.6409e-23
C_0_33 BLD iQ1:SDexcludeXG271UTiSiXG295X1 5.6722e-23
C_0_34 BLD iQ1:SDexcludeXG272UTiSiXG295X1 5.7852e-23
C_0_35 BLD iQ1:SiGeBXG285UTiSiXG296X1 1.2112e-23
C_0_36 BLD iQ1:SiGeBXG286UTiSiXG296X1 4.2839e-25
C_0_37 BLD iQ1:SiGeBXG323UTiSiXG296X1 4.2361e-25
C_0_38 BLD iQ1:SiGeBXG327UTiSiXG296X1 4.2356e-25
C_0_39 BLD iQ1:SiliconNXG302UTiSiXG295X1 3.5791e-23
C_0_40 BLD iQ1:n1d 1.0639e-22
C_0_41 BLD iQ1:n2s 1.0639e-22
C_0_42 BLD iQ1:n4g 3.6640e-23
C_0_43 BLD iQ1:p1d 6.7674e-23
C_0_44 BLD iQ1:p2g 6.6420e-23
C_0_45 BLD iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.5716e-19
C_0_46 BLD iQ2:LM00Cobalt2XG153USiGeBXG288X1 3.0831e-22
C_0_47 BLD iQ2:LM00Cobalt2XG153UTiSiXG299X1 3.0517e-22
C_0_48 BLD iQ2:LM00Cobalt2XG153UTiSiXG300X1 3.0513e-22
C_0_49 BLD iQ2:SDexcludeXG265UTiSiXG299X1 3.5567e-23
C_0_50 BLD iQ2:SDexcludeXG273UTiSiXG300X1 1.4743e-23
C_0_51 BLD iQ2:SDexcludeXG274UTiSiXG300X1 1.2952e-23
C_0_52 BLD iQ2:SiGeBXG288UTiSiXG299X1 3.2323e-24
C_0_53 BLD iQ2:SiGeBXG290UTiSiXG299X1 5.0340e-26
C_0_54 BLD iQ2:SiGeBXG328UTiSiXG299X1 4.9463e-26
C_0_55 BLD iQ2:SiliconNXG305UTiSiXG300X1 8.2491e-25
C_0_56 BLD iQ2:n1g 5.7530e-22
C_0_57 BLD iQ2:n3d 2.8501e-23
C_0_58 BLD iQ2:n4s 2.8501e-23
C_0_59 BLD iQ2:p1g 1.2742e-22
C_0_60 BLD iQ2:p2s 3.8702e-23
C_0_61 BLU WLL 3.6147e-19
C_0_62 BLU WLR 3.6147e-19
C_0_63 BLU BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 1.3609e-21
C_0_64 BLU BLB:LM00Cobalt2XG71UTiSiXG73X1 6.0485e-22
C_0_65 BLU BLB:SiliconNXG72UTiSiXG73X1 1.5984e-22
C_0_66 BLU BLB:n3s 2.8186e-22
C_0_67 BLU WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.5821e-22
C_0_68 BLU WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.5817e-23
C_0_69 BLU WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.5371e-19
C_0_70 BLU WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 8.1812e-19
C_0_71 BLU WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 5.0530e-19
C_0_72 BLU WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 9.1292e-19
C_0_73 BLU WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 3.6147e-19
C_0_74 BLU WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.5897e-23
C_0_75 BLU WL:n2g 7.2280e-22
C_0_76 BLU WL:n3g 3.9718e-23
C_0_77 BLU iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 2.3695e-19
C_0_78 BLU iQ1:LM00Cobalt2XG308USiGeBXG285X1 2.1612e-19
C_0_79 BLU iQ1:LM00Cobalt2XG308UTiSiXG295X1 2.1612e-19
C_0_80 BLU iQ1:LM00Cobalt2XG308UTiSiXG296X1 2.1611e-19
C_0_81 BLU iQ1:SDexcludeXG264UTiSiXG296X1 5.6409e-23
C_0_82 BLU iQ1:SDexcludeXG271UTiSiXG295X1 5.6722e-23
C_0_83 BLU iQ1:SDexcludeXG272UTiSiXG295X1 5.7852e-23
C_0_84 BLU iQ1:SiGeBXG285UTiSiXG296X1 1.2112e-23
C_0_85 BLU iQ1:SiGeBXG286UTiSiXG296X1 4.2839e-25
C_0_86 BLU iQ1:SiGeBXG323UTiSiXG296X1 4.2361e-25
C_0_87 BLU iQ1:SiGeBXG327UTiSiXG296X1 4.2356e-25
C_0_88 BLU iQ1:SiliconNXG302UTiSiXG295X1 3.5791e-23
C_0_89 BLU iQ1:n1d 1.0639e-22
C_0_90 BLU iQ1:n2s 1.0639e-22
C_0_91 BLU iQ1:n4g 3.6640e-23
C_0_92 BLU iQ1:p1d 6.7674e-23
C_0_93 BLU iQ1:p2g 6.6420e-23
C_0_94 BLU iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.5716e-19
C_0_95 BLU iQ2:LM00Cobalt2XG153USiGeBXG288X1 3.0831e-22
C_0_96 BLU iQ2:LM00Cobalt2XG153UTiSiXG299X1 3.0517e-22
C_0_97 BLU iQ2:LM00Cobalt2XG153UTiSiXG300X1 3.0513e-22
C_0_98 BLU iQ2:SDexcludeXG265UTiSiXG299X1 3.5567e-23
C_0_99 BLU iQ2:SDexcludeXG273UTiSiXG300X1 1.4743e-23
C_0_100 BLU iQ2:SDexcludeXG274UTiSiXG300X1 1.2952e-23
C_0_101 BLU iQ2:SiGeBXG288UTiSiXG299X1 3.2323e-24
C_0_102 BLU iQ2:SiGeBXG290UTiSiXG299X1 5.0340e-26
C_0_103 BLU iQ2:SiGeBXG328UTiSiXG299X1 4.9463e-26
C_0_104 BLU iQ2:SiliconNXG305UTiSiXG300X1 8.2491e-25
C_0_105 BLU iQ2:n1g 5.7530e-22
C_0_106 BLU iQ2:n3d 2.8501e-23
C_0_107 BLU iQ2:n4s 2.8501e-23
C_0_108 BLU iQ2:p1g 1.2742e-22
C_0_109 BLU iQ2:p2s 3.8702e-23
C_0_110 WLL BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 3.6277e-19
C_0_111 WLL BL:LM00Cobalt2XG535UTiSiXG524X1 1.3114e-21
C_0_112 WLL BL:SiliconNXG516UTiSiXG524X1 1.3653e-22
C_0_113 WLL BL:n2d 1.4670e-22
C_0_114 WLR BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 3.6277e-19
C_0_115 WLR BL:LM00Cobalt2XG535UTiSiXG524X1 1.3114e-21
C_0_116 WLR BL:SiliconNXG516UTiSiXG524X1 1.3653e-22
C_0_117 WLR BL:n2d 1.4670e-22
C_0_118 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 1.9934e-21
C_0_119 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 6.2442e-22
C_0_120 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 BLB:SiliconNXG72UTiSiXG73X1 3.2974e-22
C_0_121 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 BLB:n3s 1.5459e-21
C_0_122 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 8.2783e-22
C_0_123 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.7081e-23
C_0_124 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 2.2885e-18
C_0_125 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 1.1216e-18
C_0_126 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 5.1360e-19
C_0_127 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.0056e-18
C_0_128 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 3.6277e-19
C_0_129 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.6407e-23
C_0_130 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 WL:n2g 1.8262e-19
C_0_131 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 WL:n3g 4.6592e-22
C_0_132 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 7.6690e-19
C_0_133 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 3.0706e-19
C_0_134 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 3.0678e-19
C_0_135 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 3.0675e-19
C_0_136 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:SDexcludeXG264UTiSiXG296X1 9.8306e-22
C_0_137 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:SDexcludeXG271UTiSiXG295X1 5.8639e-22
C_0_138 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:SDexcludeXG272UTiSiXG295X1 6.3907e-22
C_0_139 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:SiGeBXG285UTiSiXG296X1 3.2135e-22
C_0_140 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:SiGeBXG286UTiSiXG296X1 3.1820e-24
C_0_141 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:SiGeBXG323UTiSiXG296X1 3.1773e-24
C_0_142 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:SiGeBXG327UTiSiXG296X1 3.1765e-24
C_0_143 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:SiliconNXG302UTiSiXG295X1 2.5116e-22
C_0_144 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:n1d 1.3606e-21
C_0_145 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:n2s 1.3606e-21
C_0_146 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:n4g 6.1196e-22
C_0_147 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:p1d 1.2981e-21
C_0_148 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ1:p2g 1.3212e-21
C_0_149 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.6058e-19
C_0_150 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 4.6604e-22
C_0_151 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 4.4912e-22
C_0_152 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 4.4902e-22
C_0_153 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:SDexcludeXG265UTiSiXG299X1 5.6294e-22
C_0_154 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:SDexcludeXG273UTiSiXG300X1 2.2681e-22
C_0_155 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:SDexcludeXG274UTiSiXG300X1 2.0119e-22
C_0_156 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:SiGeBXG288UTiSiXG299X1 1.7154e-23
C_0_157 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:SiGeBXG290UTiSiXG299X1 1.2448e-25
C_0_158 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:SiGeBXG328UTiSiXG299X1 1.2070e-25
C_0_159 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:SiliconNXG305UTiSiXG300X1 1.1322e-23
C_0_160 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:n1g 1.3386e-21
C_0_161 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:n3d 4.3925e-22
C_0_162 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:n4s 4.3925e-22
C_0_163 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:p1g 4.7465e-22
C_0_164 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 iQ2:p2s 5.7985e-22
C_0_165 BL:LM00Cobalt2XG535UTiSiXG524X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 6.4066e-22
C_0_166 BL:LM00Cobalt2XG535UTiSiXG524X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 2.0710e-23
C_0_167 BL:LM00Cobalt2XG535UTiSiXG524X1 BLB:SiliconNXG72UTiSiXG73X1 1.7985e-22
C_0_168 BL:LM00Cobalt2XG535UTiSiXG524X1 BLB:n3s 1.3376e-21
C_0_169 BL:LM00Cobalt2XG535UTiSiXG524X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 7.0822e-22
C_0_170 BL:LM00Cobalt2XG535UTiSiXG524X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.3342e-24
C_0_171 BL:LM00Cobalt2XG535UTiSiXG524X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 2.1520e-18
C_0_172 BL:LM00Cobalt2XG535UTiSiXG524X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 3.0485e-19
C_0_173 BL:LM00Cobalt2XG535UTiSiXG524X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 8.3509e-21
C_0_174 BL:LM00Cobalt2XG535UTiSiXG524X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 9.3105e-20
C_0_175 BL:LM00Cobalt2XG535UTiSiXG524X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 1.3115e-21
C_0_176 BL:LM00Cobalt2XG535UTiSiXG524X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 5.3539e-25
C_0_177 BL:LM00Cobalt2XG535UTiSiXG524X1 WL:n2g 1.8935e-19
C_0_178 BL:LM00Cobalt2XG535UTiSiXG524X1 WL:n3g 4.5078e-22
C_0_179 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 5.3605e-19
C_0_180 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 9.1104e-20
C_0_181 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 9.0818e-20
C_0_182 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 9.0796e-20
C_0_183 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:SDexcludeXG264UTiSiXG296X1 9.7575e-22
C_0_184 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:SDexcludeXG271UTiSiXG295X1 5.6306e-22
C_0_185 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:SDexcludeXG272UTiSiXG295X1 6.1530e-22
C_0_186 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:SiGeBXG285UTiSiXG296X1 3.1355e-22
C_0_187 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:SiGeBXG286UTiSiXG296X1 2.7691e-24
C_0_188 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:SiGeBXG323UTiSiXG296X1 2.7692e-24
C_0_189 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:SiGeBXG327UTiSiXG296X1 2.7684e-24
C_0_190 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:SiliconNXG302UTiSiXG295X1 2.1900e-22
C_0_191 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:n1d 1.3251e-21
C_0_192 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:n2s 1.3251e-21
C_0_193 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:n4g 6.0571e-22
C_0_194 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:p1d 1.2838e-21
C_0_195 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ1:p2g 1.3058e-21
C_0_196 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 3.5946e-21
C_0_197 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 1.5965e-22
C_0_198 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 1.4520e-22
C_0_199 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 1.4514e-22
C_0_200 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:SDexcludeXG265UTiSiXG299X1 5.5605e-22
C_0_201 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:SDexcludeXG273UTiSiXG300X1 2.2396e-22
C_0_202 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.9894e-22
C_0_203 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:SiGeBXG288UTiSiXG299X1 1.4594e-23
C_0_204 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:SiGeBXG290UTiSiXG299X1 7.4807e-26
C_0_205 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:SiGeBXG328UTiSiXG299X1 7.1843e-26
C_0_206 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:SiliconNXG305UTiSiXG300X1 1.1089e-23
C_0_207 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:n1g 8.1129e-22
C_0_208 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:n3d 4.3394e-22
C_0_209 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:n4s 4.3394e-22
C_0_210 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:p1g 3.6746e-22
C_0_211 BL:LM00Cobalt2XG535UTiSiXG524X1 iQ2:p2s 5.7050e-22
C_0_212 BL:SiliconNXG516UTiSiXG524X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 3.1403e-22
C_0_213 BL:SiliconNXG516UTiSiXG524X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 1.7134e-22
C_0_214 BL:SiliconNXG516UTiSiXG524X1 BLB:SiliconNXG72UTiSiXG73X1 1.4792e-21
C_0_215 BL:SiliconNXG516UTiSiXG524X1 BLB:n3s 1.0903e-20
C_0_216 BL:SiliconNXG516UTiSiXG524X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 5.6393e-21
C_0_217 BL:SiliconNXG516UTiSiXG524X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.0233e-23
C_0_218 BL:SiliconNXG516UTiSiXG524X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 2.3327e-18
C_0_219 BL:SiliconNXG516UTiSiXG524X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 6.6920e-20
C_0_220 BL:SiliconNXG516UTiSiXG524X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 1.2112e-21
C_0_221 BL:SiliconNXG516UTiSiXG524X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.0842e-20
C_0_222 BL:SiliconNXG516UTiSiXG524X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 1.3659e-22
C_0_223 BL:SiliconNXG516UTiSiXG524X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 3.5931e-24
C_0_224 BL:SiliconNXG516UTiSiXG524X1 WL:n2g 7.4548e-21
C_0_225 BL:SiliconNXG516UTiSiXG524X1 WL:n3g 2.4583e-23
C_0_226 BL:SiliconNXG516UTiSiXG524X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 3.0110e-19
C_0_227 BL:SiliconNXG516UTiSiXG524X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 3.7600e-21
C_0_228 BL:SiliconNXG516UTiSiXG524X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 3.1856e-21
C_0_229 BL:SiliconNXG516UTiSiXG524X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 3.1800e-21
C_0_230 BL:SiliconNXG516UTiSiXG524X1 iQ1:SDexcludeXG264UTiSiXG296X1 6.8256e-21
C_0_231 BL:SiliconNXG516UTiSiXG524X1 iQ1:SDexcludeXG271UTiSiXG295X1 6.5124e-21
C_0_232 BL:SiliconNXG516UTiSiXG524X1 iQ1:SDexcludeXG272UTiSiXG295X1 5.9446e-21
C_0_233 BL:SiliconNXG516UTiSiXG524X1 iQ1:SiGeBXG285UTiSiXG296X1 5.8244e-22
C_0_234 BL:SiliconNXG516UTiSiXG524X1 iQ1:SiGeBXG286UTiSiXG296X1 1.2544e-24
C_0_235 BL:SiliconNXG516UTiSiXG524X1 iQ1:SiGeBXG323UTiSiXG296X1 1.2545e-24
C_0_236 BL:SiliconNXG516UTiSiXG524X1 iQ1:SiGeBXG327UTiSiXG296X1 1.2476e-24
C_0_237 BL:SiliconNXG516UTiSiXG524X1 iQ1:SiliconNXG302UTiSiXG295X1 5.6854e-22
C_0_238 BL:SiliconNXG516UTiSiXG524X1 iQ1:n1d 1.3005e-20
C_0_239 BL:SiliconNXG516UTiSiXG524X1 iQ1:n2s 1.3005e-20
C_0_240 BL:SiliconNXG516UTiSiXG524X1 iQ1:n4g 3.0389e-23
C_0_241 BL:SiliconNXG516UTiSiXG524X1 iQ1:p1d 7.4055e-21
C_0_242 BL:SiliconNXG516UTiSiXG524X1 iQ1:p2g 5.0950e-23
C_0_243 BL:SiliconNXG516UTiSiXG524X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.3766e-20
C_0_244 BL:SiliconNXG516UTiSiXG524X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 1.1793e-22
C_0_245 BL:SiliconNXG516UTiSiXG524X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.8972e-23
C_0_246 BL:SiliconNXG516UTiSiXG524X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.9065e-23
C_0_247 BL:SiliconNXG516UTiSiXG524X1 iQ2:SDexcludeXG265UTiSiXG299X1 3.8174e-21
C_0_248 BL:SiliconNXG516UTiSiXG524X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.6770e-21
C_0_249 BL:SiliconNXG516UTiSiXG524X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.5402e-21
C_0_250 BL:SiliconNXG516UTiSiXG524X1 iQ2:SiGeBXG288UTiSiXG299X1 8.8980e-23
C_0_251 BL:SiliconNXG516UTiSiXG524X1 iQ2:SiGeBXG290UTiSiXG299X1 2.5668e-26
C_0_252 BL:SiliconNXG516UTiSiXG524X1 iQ2:SiGeBXG328UTiSiXG299X1 1.3617e-26
C_0_253 BL:SiliconNXG516UTiSiXG524X1 iQ2:SiliconNXG305UTiSiXG300X1 8.3507e-23
C_0_254 BL:SiliconNXG516UTiSiXG524X1 iQ2:n1g 4.8023e-23
C_0_255 BL:SiliconNXG516UTiSiXG524X1 iQ2:n3d 3.3004e-21
C_0_256 BL:SiliconNXG516UTiSiXG524X1 iQ2:n4s 3.3004e-21
C_0_257 BL:SiliconNXG516UTiSiXG524X1 iQ2:p1g 2.0231e-23
C_0_258 BL:SiliconNXG516UTiSiXG524X1 iQ2:p2s 3.9064e-21
C_0_259 BL:n2d BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 1.4737e-21
C_0_260 BL:n2d BLB:LM00Cobalt2XG71UTiSiXG73X1 1.2757e-21
C_0_261 BL:n2d BLB:SiliconNXG72UTiSiXG73X1 1.0914e-20
C_0_262 BL:n2d BLB:n3s 8.0051e-20
C_0_263 BL:n2d WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 4.1053e-20
C_0_264 BL:n2d WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 7.5213e-23
C_0_265 BL:n2d WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 5.5776e-18
C_0_266 BL:n2d WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 7.2900e-20
C_0_267 BL:n2d WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 1.2803e-21
C_0_268 BL:n2d WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.1475e-20
C_0_269 BL:n2d WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 1.4719e-22
C_0_270 BL:n2d WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 2.6359e-23
C_0_271 BL:n2d iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 6.3467e-19
C_0_272 BL:n2d iQ1:LM00Cobalt2XG308USiGeBXG285X1 5.7102e-21
C_0_273 BL:n2d iQ1:LM00Cobalt2XG308UTiSiXG295X1 3.8241e-21
C_0_274 BL:n2d iQ1:LM00Cobalt2XG308UTiSiXG296X1 3.8148e-21
C_0_275 BL:n2d iQ1:SDexcludeXG264UTiSiXG296X1 4.8858e-20
C_0_276 BL:n2d iQ1:SDexcludeXG271UTiSiXG295X1 1.0571e-19
C_0_277 BL:n2d iQ1:SDexcludeXG272UTiSiXG295X1 9.8035e-20
C_0_278 BL:n2d iQ1:SiGeBXG285UTiSiXG296X1 1.8983e-21
C_0_279 BL:n2d iQ1:SiGeBXG286UTiSiXG296X1 1.5338e-24
C_0_280 BL:n2d iQ1:SiGeBXG323UTiSiXG296X1 1.5565e-24
C_0_281 BL:n2d iQ1:SiGeBXG327UTiSiXG296X1 1.5086e-24
C_0_282 BL:n2d iQ1:SiliconNXG302UTiSiXG295X1 3.7047e-21
C_0_283 BL:n2d iQ1:n1d 2.0741e-19
C_0_284 BL:n2d iQ1:n2s 2.0741e-19
C_0_285 BL:n2d iQ1:p1d 5.0753e-20
C_0_286 BL:n2d iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.9546e-19
C_0_287 BL:n2d iQ2:LM00Cobalt2XG153USiGeBXG288X1 6.9423e-22
C_0_288 BL:n2d iQ2:LM00Cobalt2XG153UTiSiXG299X1 7.9857e-23
C_0_289 BL:n2d iQ2:LM00Cobalt2XG153UTiSiXG300X1 8.0578e-23
C_0_290 BL:n2d iQ2:SDexcludeXG265UTiSiXG299X1 2.6154e-20
C_0_291 BL:n2d iQ2:SDexcludeXG273UTiSiXG300X1 1.1937e-20
C_0_292 BL:n2d iQ2:SDexcludeXG274UTiSiXG300X1 1.1090e-20
C_0_293 BL:n2d iQ2:SiGeBXG288UTiSiXG299X1 6.1444e-22
C_0_294 BL:n2d iQ2:SiGeBXG290UTiSiXG299X1 7.4926e-26
C_0_295 BL:n2d iQ2:SiGeBXG328UTiSiXG299X1 3.3977e-26
C_0_296 BL:n2d iQ2:SiliconNXG305UTiSiXG300X1 5.9599e-22
C_0_297 BL:n2d iQ2:n3d 2.3620e-20
C_0_298 BL:n2d iQ2:n4s 2.3620e-20
C_0_299 BL:n2d iQ2:p2s 2.6768e-20
R_0_0 BLD BLU 1.1572e+01
R_0_1 BLD BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 3.4048e+01
R_0_2 BLU BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 1.0482e+03
R_0_3 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 BL:LM00Cobalt2XG535UTiSiXG524X1 5.8596e+01
R_0_4 BL:LM00Cobalt2XG535UTiSiXG524X1 BL:SiliconNXG516UTiSiXG524X1 1.8658e+02
R_0_5 BL:SiliconNXG516UTiSiXG524X1 BL:n2d 2.1209e+01

*|NET BLB 4.8687e-05PF
C_1_0 BLBD WLL 3.6209e-19
C_1_1 BLBD WLR 3.6209e-19
C_1_2 BLBD WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.4916e-19
C_1_3 BLBD WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 8.2754e-19
C_1_4 BLBD WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.5007e-22
C_1_5 BLBD WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 1.0911e-23
C_1_6 BLBD WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 3.6210e-19
C_1_7 BLBD WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.2296e-23
C_1_8 BLBD WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 4.7435e-19
C_1_9 BLBD WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 8.9524e-19
C_1_10 BLBD WL:n2g 3.8868e-23
C_1_11 BLBD WL:n3g 7.0100e-22
C_1_12 BLBD iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 1.5708e-19
C_1_13 BLBD iQ1:LM00Cobalt2XG308USiGeBXG285X1 3.0446e-22
C_1_14 BLBD iQ1:LM00Cobalt2XG308UTiSiXG295X1 3.0130e-22
C_1_15 BLBD iQ1:LM00Cobalt2XG308UTiSiXG296X1 3.0133e-22
C_1_16 BLBD iQ1:SDexcludeXG264UTiSiXG296X1 3.5259e-23
C_1_17 BLBD iQ1:SDexcludeXG271UTiSiXG295X1 1.2746e-23
C_1_18 BLBD iQ1:SDexcludeXG272UTiSiXG295X1 1.4571e-23
C_1_19 BLBD iQ1:SiGeBXG285UTiSiXG296X1 3.2053e-24
C_1_20 BLBD iQ1:SiGeBXG286UTiSiXG296X1 3.8025e-26
C_1_21 BLBD iQ1:SiGeBXG323UTiSiXG296X1 3.7840e-26
C_1_22 BLBD iQ1:SiGeBXG327UTiSiXG296X1 3.7795e-26
C_1_23 BLBD iQ1:SiliconNXG302UTiSiXG295X1 8.0655e-25
C_1_24 BLBD iQ1:n1d 2.8110e-23
C_1_25 BLBD iQ1:n2s 2.8110e-23
C_1_26 BLBD iQ1:n4g 5.7685e-22
C_1_27 BLBD iQ1:p1d 3.8389e-23
C_1_28 BLBD iQ1:p2g 1.2567e-22
C_1_29 BLBD iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.3741e-19
C_1_30 BLBD iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.1600e-19
C_1_31 BLBD iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.1599e-19
C_1_32 BLBD iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.1601e-19
C_1_33 BLBD iQ2:SDexcludeXG265UTiSiXG299X1 5.5971e-23
C_1_34 BLBD iQ2:SDexcludeXG273UTiSiXG300X1 6.1101e-23
C_1_35 BLBD iQ2:SDexcludeXG274UTiSiXG300X1 6.0039e-23
C_1_36 BLBD iQ2:SiGeBXG288UTiSiXG299X1 1.2327e-23
C_1_37 BLBD iQ2:SiGeBXG290UTiSiXG299X1 4.6667e-25
C_1_38 BLBD iQ2:SiGeBXG328UTiSiXG299X1 4.7073e-25
C_1_39 BLBD iQ2:SiliconNXG305UTiSiXG300X1 4.6686e-23
C_1_40 BLBD iQ2:n1g 3.6323e-23
C_1_41 BLBD iQ2:n3d 1.1193e-22
C_1_42 BLBD iQ2:n4s 1.1193e-22
C_1_43 BLBD iQ2:p1g 6.7180e-23
C_1_44 BLBD iQ2:p2s 6.7366e-23
C_1_45 BLBU WLL 3.6209e-19
C_1_46 BLBU WLR 3.6209e-19
C_1_47 BLBU WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.4916e-19
C_1_48 BLBU WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 8.2754e-19
C_1_49 BLBU WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.5007e-22
C_1_50 BLBU WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 1.0911e-23
C_1_51 BLBU WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 3.6210e-19
C_1_52 BLBU WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.2296e-23
C_1_53 BLBU WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 4.7435e-19
C_1_54 BLBU WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 8.9524e-19
C_1_55 BLBU WL:n2g 3.8868e-23
C_1_56 BLBU WL:n3g 7.0100e-22
C_1_57 BLBU iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 1.5708e-19
C_1_58 BLBU iQ1:LM00Cobalt2XG308USiGeBXG285X1 3.0446e-22
C_1_59 BLBU iQ1:LM00Cobalt2XG308UTiSiXG295X1 3.0130e-22
C_1_60 BLBU iQ1:LM00Cobalt2XG308UTiSiXG296X1 3.0133e-22
C_1_61 BLBU iQ1:SDexcludeXG264UTiSiXG296X1 3.5259e-23
C_1_62 BLBU iQ1:SDexcludeXG271UTiSiXG295X1 1.2746e-23
C_1_63 BLBU iQ1:SDexcludeXG272UTiSiXG295X1 1.4571e-23
C_1_64 BLBU iQ1:SiGeBXG285UTiSiXG296X1 3.2053e-24
C_1_65 BLBU iQ1:SiGeBXG286UTiSiXG296X1 3.8025e-26
C_1_66 BLBU iQ1:SiGeBXG323UTiSiXG296X1 3.7840e-26
C_1_67 BLBU iQ1:SiGeBXG327UTiSiXG296X1 3.7795e-26
C_1_68 BLBU iQ1:SiliconNXG302UTiSiXG295X1 8.0655e-25
C_1_69 BLBU iQ1:n1d 2.8110e-23
C_1_70 BLBU iQ1:n2s 2.8110e-23
C_1_71 BLBU iQ1:n4g 5.7685e-22
C_1_72 BLBU iQ1:p1d 3.8389e-23
C_1_73 BLBU iQ1:p2g 1.2567e-22
C_1_74 BLBU iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.3741e-19
C_1_75 BLBU iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.1600e-19
C_1_76 BLBU iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.1599e-19
C_1_77 BLBU iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.1601e-19
C_1_78 BLBU iQ2:SDexcludeXG265UTiSiXG299X1 5.5971e-23
C_1_79 BLBU iQ2:SDexcludeXG273UTiSiXG300X1 6.1101e-23
C_1_80 BLBU iQ2:SDexcludeXG274UTiSiXG300X1 6.0039e-23
C_1_81 BLBU iQ2:SiGeBXG288UTiSiXG299X1 1.2327e-23
C_1_82 BLBU iQ2:SiGeBXG290UTiSiXG299X1 4.6667e-25
C_1_83 BLBU iQ2:SiGeBXG328UTiSiXG299X1 4.7073e-25
C_1_84 BLBU iQ2:SiliconNXG305UTiSiXG300X1 4.6686e-23
C_1_85 BLBU iQ2:n1g 3.6323e-23
C_1_86 BLBU iQ2:n3d 1.1193e-22
C_1_87 BLBU iQ2:n4s 1.1193e-22
C_1_88 BLBU iQ2:p1g 6.7180e-23
C_1_89 BLBU iQ2:p2s 6.7366e-23
C_1_90 WLL BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 3.6328e-19
C_1_91 WLL BLB:LM00Cobalt2XG71UTiSiXG73X1 1.1977e-21
C_1_92 WLL BLB:SiliconNXG72UTiSiXG73X1 1.2251e-22
C_1_93 WLL BLB:n3s 1.3194e-22
C_1_94 WLR BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 3.6328e-19
C_1_95 WLR BLB:LM00Cobalt2XG71UTiSiXG73X1 1.1977e-21
C_1_96 WLR BLB:SiliconNXG72UTiSiXG73X1 1.2251e-22
C_1_97 WLR BLB:n3s 1.3194e-22
C_1_98 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 2.2536e-18
C_1_99 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.1561e-18
C_1_100 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 7.8713e-22
C_1_101 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 1.2072e-23
C_1_102 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 3.6329e-19
C_1_103 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.2751e-23
C_1_104 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 4.7785e-19
C_1_105 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.0140e-18
C_1_106 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 WL:n2g 4.4347e-22
C_1_107 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 WL:n3g 1.8212e-19
C_1_108 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 1.6036e-19
C_1_109 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 4.5469e-22
C_1_110 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 4.3839e-22
C_1_111 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 4.3847e-22
C_1_112 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:SDexcludeXG264UTiSiXG296X1 5.3626e-22
C_1_113 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:SDexcludeXG271UTiSiXG295X1 1.9145e-22
C_1_114 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:SDexcludeXG272UTiSiXG295X1 2.1639e-22
C_1_115 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:SiGeBXG285UTiSiXG296X1 1.6389e-23
C_1_116 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:SiGeBXG286UTiSiXG296X1 8.9845e-26
C_1_117 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:SiGeBXG323UTiSiXG296X1 8.9231e-26
C_1_118 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:SiGeBXG327UTiSiXG296X1 8.8435e-26
C_1_119 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:SiliconNXG302UTiSiXG295X1 1.0724e-23
C_1_120 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:n1d 4.1854e-22
C_1_121 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:n2s 4.1854e-22
C_1_122 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:n4g 1.3106e-21
C_1_123 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:p1d 5.5247e-22
C_1_124 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ1:p2g 4.5721e-22
C_1_125 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 7.3116e-19
C_1_126 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 3.0409e-19
C_1_127 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 3.0380e-19
C_1_128 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 3.0384e-19
C_1_129 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:SDexcludeXG265UTiSiXG299X1 9.3301e-22
C_1_130 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:SDexcludeXG273UTiSiXG300X1 6.1626e-22
C_1_131 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:SDexcludeXG274UTiSiXG300X1 5.7145e-22
C_1_132 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:SiGeBXG288UTiSiXG299X1 2.9541e-22
C_1_133 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:SiGeBXG290UTiSiXG299X1 3.3053e-24
C_1_134 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:SiGeBXG328UTiSiXG299X1 3.3076e-24
C_1_135 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:SiliconNXG305UTiSiXG300X1 2.4723e-22
C_1_136 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:n1g 5.8223e-22
C_1_137 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:n3d 1.3080e-21
C_1_138 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:n4s 1.3080e-21
C_1_139 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:p1g 1.2489e-21
C_1_140 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 iQ2:p2s 1.2218e-21
C_1_141 BLB:LM00Cobalt2XG71UTiSiXG73X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 2.1220e-18
C_1_142 BLB:LM00Cobalt2XG71UTiSiXG73X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 3.3003e-19
C_1_143 BLB:LM00Cobalt2XG71UTiSiXG73X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 6.7635e-22
C_1_144 BLB:LM00Cobalt2XG71UTiSiXG73X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 1.2259e-24
C_1_145 BLB:LM00Cobalt2XG71UTiSiXG73X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 1.1978e-21
C_1_146 BLB:LM00Cobalt2XG71UTiSiXG73X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 4.7570e-25
C_1_147 BLB:LM00Cobalt2XG71UTiSiXG73X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 3.5155e-21
C_1_148 BLB:LM00Cobalt2XG71UTiSiXG73X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.1928e-19
C_1_149 BLB:LM00Cobalt2XG71UTiSiXG73X1 WL:n2g 4.2959e-22
C_1_150 BLB:LM00Cobalt2XG71UTiSiXG73X1 WL:n3g 1.8881e-19
C_1_151 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 3.4591e-21
C_1_152 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 1.5224e-22
C_1_153 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.3842e-22
C_1_154 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.3847e-22
C_1_155 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:SDexcludeXG264UTiSiXG296X1 5.3034e-22
C_1_156 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:SDexcludeXG271UTiSiXG295X1 1.8960e-22
C_1_157 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:SDexcludeXG272UTiSiXG295X1 2.1397e-22
C_1_158 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:SiGeBXG285UTiSiXG296X1 1.3870e-23
C_1_159 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:SiGeBXG286UTiSiXG296X1 5.2443e-26
C_1_160 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:SiGeBXG323UTiSiXG296X1 5.1958e-26
C_1_161 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:SiGeBXG327UTiSiXG296X1 5.1158e-26
C_1_162 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:SiliconNXG302UTiSiXG295X1 1.0517e-23
C_1_163 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:n1d 4.1408e-22
C_1_164 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:n2s 4.1408e-22
C_1_165 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:n4g 7.8277e-22
C_1_166 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:p1d 5.4411e-22
C_1_167 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ1:p2g 3.5223e-22
C_1_168 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 5.0039e-19
C_1_169 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 8.8268e-20
C_1_170 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 8.7986e-20
C_1_171 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 8.8007e-20
C_1_172 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:SDexcludeXG265UTiSiXG299X1 9.2730e-22
C_1_173 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:SDexcludeXG273UTiSiXG300X1 5.8980e-22
C_1_174 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:SDexcludeXG274UTiSiXG300X1 5.4532e-22
C_1_175 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:SiGeBXG288UTiSiXG299X1 2.8792e-22
C_1_176 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:SiGeBXG290UTiSiXG299X1 2.8598e-24
C_1_177 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:SiGeBXG328UTiSiXG299X1 2.8580e-24
C_1_178 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:SiliconNXG305UTiSiXG300X1 2.0454e-22
C_1_179 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:n1g 5.7692e-22
C_1_180 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:n3d 1.2683e-21
C_1_181 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:n4s 1.2683e-21
C_1_182 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:p1g 1.2343e-21
C_1_183 BLB:LM00Cobalt2XG71UTiSiXG73X1 iQ2:p2s 1.2095e-21
C_1_184 BLB:SiliconNXG72UTiSiXG73X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 2.3258e-18
C_1_185 BLB:SiliconNXG72UTiSiXG73X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 7.0578e-20
C_1_186 BLB:SiliconNXG72UTiSiXG73X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 5.6551e-21
C_1_187 BLB:SiliconNXG72UTiSiXG73X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 9.3445e-24
C_1_188 BLB:SiliconNXG72UTiSiXG73X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 1.2282e-22
C_1_189 BLB:SiliconNXG72UTiSiXG73X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 2.7428e-24
C_1_190 BLB:SiliconNXG72UTiSiXG73X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 4.6260e-22
C_1_191 BLB:SiliconNXG72UTiSiXG73X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.4611e-20
C_1_192 BLB:SiliconNXG72UTiSiXG73X1 WL:n2g 2.4989e-23
C_1_193 BLB:SiliconNXG72UTiSiXG73X1 WL:n3g 7.3897e-21
C_1_194 BLB:SiliconNXG72UTiSiXG73X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 2.3847e-20
C_1_195 BLB:SiliconNXG72UTiSiXG73X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 1.1928e-22
C_1_196 BLB:SiliconNXG72UTiSiXG73X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 3.0235e-23
C_1_197 BLB:SiliconNXG72UTiSiXG73X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 3.0232e-23
C_1_198 BLB:SiliconNXG72UTiSiXG73X1 iQ1:SDexcludeXG264UTiSiXG296X1 3.8356e-21
C_1_199 BLB:SiliconNXG72UTiSiXG73X1 iQ1:SDexcludeXG271UTiSiXG295X1 1.5409e-21
C_1_200 BLB:SiliconNXG72UTiSiXG73X1 iQ1:SDexcludeXG272UTiSiXG295X1 1.6835e-21
C_1_201 BLB:SiliconNXG72UTiSiXG73X1 iQ1:SiGeBXG285UTiSiXG296X1 8.9086e-23
C_1_202 BLB:SiliconNXG72UTiSiXG73X1 iQ1:SiGeBXG286UTiSiXG296X1 2.9640e-26
C_1_203 BLB:SiliconNXG72UTiSiXG73X1 iQ1:SiGeBXG323UTiSiXG296X1 2.3590e-26
C_1_204 BLB:SiliconNXG72UTiSiXG73X1 iQ1:SiGeBXG327UTiSiXG296X1 1.6772e-26
C_1_205 BLB:SiliconNXG72UTiSiXG73X1 iQ1:SiliconNXG302UTiSiXG295X1 8.3263e-23
C_1_206 BLB:SiliconNXG72UTiSiXG73X1 iQ1:n1d 3.3076e-21
C_1_207 BLB:SiliconNXG72UTiSiXG73X1 iQ1:n2s 3.3076e-21
C_1_208 BLB:SiliconNXG72UTiSiXG73X1 iQ1:n4g 4.9001e-23
C_1_209 BLB:SiliconNXG72UTiSiXG73X1 iQ1:p1d 3.9247e-21
C_1_210 BLB:SiliconNXG72UTiSiXG73X1 iQ1:p2g 2.0688e-23
C_1_211 BLB:SiliconNXG72UTiSiXG73X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 3.0987e-19
C_1_212 BLB:SiliconNXG72UTiSiXG73X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 4.0436e-21
C_1_213 BLB:SiliconNXG72UTiSiXG73X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 3.4519e-21
C_1_214 BLB:SiliconNXG72UTiSiXG73X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 3.4582e-21
C_1_215 BLB:SiliconNXG72UTiSiXG73X1 iQ2:SDexcludeXG265UTiSiXG299X1 6.8495e-21
C_1_216 BLB:SiliconNXG72UTiSiXG73X1 iQ2:SDexcludeXG273UTiSiXG300X1 5.9413e-21
C_1_217 BLB:SiliconNXG72UTiSiXG73X1 iQ2:SDexcludeXG274UTiSiXG300X1 6.5224e-21
C_1_218 BLB:SiliconNXG72UTiSiXG73X1 iQ2:SiGeBXG288UTiSiXG299X1 5.9458e-22
C_1_219 BLB:SiliconNXG72UTiSiXG73X1 iQ2:SiGeBXG290UTiSiXG299X1 1.4949e-24
C_1_220 BLB:SiliconNXG72UTiSiXG73X1 iQ2:SiGeBXG328UTiSiXG299X1 1.4882e-24
C_1_221 BLB:SiliconNXG72UTiSiXG73X1 iQ2:SiliconNXG305UTiSiXG300X1 5.7947e-22
C_1_222 BLB:SiliconNXG72UTiSiXG73X1 iQ2:n1g 3.1005e-23
C_1_223 BLB:SiliconNXG72UTiSiXG73X1 iQ2:n3d 1.3020e-20
C_1_224 BLB:SiliconNXG72UTiSiXG73X1 iQ2:n4s 1.3020e-20
C_1_225 BLB:SiliconNXG72UTiSiXG73X1 iQ2:p1g 5.2590e-23
C_1_226 BLB:SiliconNXG72UTiSiXG73X1 iQ2:p2s 7.4411e-21
C_1_227 BLB:n3s WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 5.5769e-18
C_1_228 BLB:n3s WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 7.6771e-20
C_1_229 BLB:n3s WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 4.1117e-20
C_1_230 BLB:n3s WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 6.8424e-23
C_1_231 BLB:n3s WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 1.3417e-22
C_1_232 BLB:n3s WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.9907e-23
C_1_233 BLB:n3s WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 4.9016e-22
C_1_234 BLB:n3s WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.5460e-20
C_1_235 BLB:n3s iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 1.9573e-19
C_1_236 BLB:n3s iQ1:LM00Cobalt2XG308USiGeBXG285X1 6.9557e-22
C_1_237 BLB:n3s iQ1:LM00Cobalt2XG308UTiSiXG295X1 8.1699e-23
C_1_238 BLB:n3s iQ1:LM00Cobalt2XG308UTiSiXG296X1 8.1625e-23
C_1_239 BLB:n3s iQ1:SDexcludeXG264UTiSiXG296X1 2.6228e-20
C_1_240 BLB:n3s iQ1:SDexcludeXG271UTiSiXG295X1 1.1077e-20
C_1_241 BLB:n3s iQ1:SDexcludeXG272UTiSiXG295X1 1.1963e-20
C_1_242 BLB:n3s iQ1:SiGeBXG285UTiSiXG296X1 6.1409e-22
C_1_243 BLB:n3s iQ1:SiGeBXG286UTiSiXG296X1 1.0879e-25
C_1_244 BLB:n3s iQ1:SiGeBXG323UTiSiXG296X1 1.1693e-25
C_1_245 BLB:n3s iQ1:SiGeBXG327UTiSiXG296X1 6.9740e-26
C_1_246 BLB:n3s iQ1:SiliconNXG302UTiSiXG295X1 5.9325e-22
C_1_247 BLB:n3s iQ1:n1d 2.3633e-20
C_1_248 BLB:n3s iQ1:n2s 2.3633e-20
C_1_249 BLB:n3s iQ1:p1d 2.6842e-20
C_1_250 BLB:n3s iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 6.4274e-19
C_1_251 BLB:n3s iQ2:LM00Cobalt2XG153USiGeBXG288X1 6.0029e-21
C_1_252 BLB:n3s iQ2:LM00Cobalt2XG153UTiSiXG299X1 4.0931e-21
C_1_253 BLB:n3s iQ2:LM00Cobalt2XG153UTiSiXG300X1 4.1056e-21
C_1_254 BLB:n3s iQ2:SDexcludeXG265UTiSiXG299X1 4.8903e-20
C_1_255 BLB:n3s iQ2:SDexcludeXG273UTiSiXG300X1 9.7783e-20
C_1_256 BLB:n3s iQ2:SDexcludeXG274UTiSiXG300X1 1.0574e-19
C_1_257 BLB:n3s iQ2:SiGeBXG288UTiSiXG299X1 1.9133e-21
C_1_258 BLB:n3s iQ2:SiGeBXG290UTiSiXG299X1 1.7889e-24
C_1_259 BLB:n3s iQ2:SiGeBXG328UTiSiXG299X1 1.7502e-24
C_1_260 BLB:n3s iQ2:SiliconNXG305UTiSiXG300X1 3.7285e-21
C_1_261 BLB:n3s iQ2:n3d 2.0720e-19
C_1_262 BLB:n3s iQ2:n4s 2.0720e-19
C_1_263 BLB:n3s iQ2:p2s 5.0813e-20
R_1_0 BLBD BLBU 1.1604e+01
R_1_1 BLBD BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 1.0561e+03
R_1_2 BLBU BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 3.4181e+01
R_1_3 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 5.9151e+01
R_1_4 BLB:LM00Cobalt2XG71UTiSiXG73X1 BLB:SiliconNXG72UTiSiXG73X1 1.8634e+02
R_1_5 BLB:SiliconNXG72UTiSiXG73X1 BLB:n3s 1.9078e+01

*|NET VDD 6.6149e-05PF
C_2_0 BLBD VDD 7.6358e-19
C_2_1 BLBD VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 8.4220e-19
C_2_2 BLBD VDD:LM00Cobalt2XG537UTiSiXG528X1 7.8879e-20
C_2_3 BLBD VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 7.7084e-19
C_2_4 BLBD VDD:LM00Cobalt2XG58UTiSiXG60X1 7.3306e-21
C_2_5 BLBD VDD:SiGeBXG512UTiSiXG528X1 2.4759e-21
C_2_6 BLBD VDD:SiGeBXG59UTiSiXG60X1 1.0206e-21
C_2_7 BLBD VDD:p1s 1.2489e-21
C_2_8 BLBD VDD:p2d 2.6305e-21
C_2_9 BLBU VDD 7.6358e-19
C_2_10 BLBU VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 8.4220e-19
C_2_11 BLBU VDD:LM00Cobalt2XG537UTiSiXG528X1 7.8879e-20
C_2_12 BLBU VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 7.7084e-19
C_2_13 BLBU VDD:LM00Cobalt2XG58UTiSiXG60X1 7.3306e-21
C_2_14 BLBU VDD:SiGeBXG512UTiSiXG528X1 2.4759e-21
C_2_15 BLBU VDD:SiGeBXG59UTiSiXG60X1 1.0206e-21
C_2_16 BLBU VDD:p1s 1.2489e-21
C_2_17 BLBU VDD:p2d 2.6305e-21
C_2_18 BLD VDD 7.6414e-19
C_2_19 BLD VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 7.7135e-19
C_2_20 BLD VDD:LM00Cobalt2XG537UTiSiXG528X1 7.2758e-21
C_2_21 BLD VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 8.4363e-19
C_2_22 BLD VDD:LM00Cobalt2XG58UTiSiXG60X1 7.9748e-20
C_2_23 BLD VDD:SiGeBXG512UTiSiXG528X1 1.0077e-21
C_2_24 BLD VDD:SiGeBXG59UTiSiXG60X1 2.5100e-21
C_2_25 BLD VDD:p1s 2.6694e-21
C_2_26 BLD VDD:p2d 1.2330e-21
C_2_27 BLU VDD 7.6414e-19
C_2_28 BLU VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 7.7135e-19
C_2_29 BLU VDD:LM00Cobalt2XG537UTiSiXG528X1 7.2758e-21
C_2_30 BLU VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 8.4363e-19
C_2_31 BLU VDD:LM00Cobalt2XG58UTiSiXG60X1 7.9748e-20
C_2_32 BLU VDD:SiGeBXG512UTiSiXG528X1 1.0077e-21
C_2_33 BLU VDD:SiGeBXG59UTiSiXG60X1 2.5100e-21
C_2_34 BLU VDD:p1s 2.6694e-21
C_2_35 BLU VDD:p2d 1.2330e-21
C_2_36 VDD VSS 1.3396e-18
C_2_37 VDD VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 3.9112e-20
C_2_38 VDD VSS:LM00Cobalt2XG21UTiSiXG30X1 3.5996e-20
C_2_39 VDD VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 3.9576e-20
C_2_40 VDD VSS:LM00Cobalt2XG539UTiSiXG530X1 3.6395e-20
C_2_41 VDD VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 4.5675e-21
C_2_42 VDD VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 4.6912e-21
C_2_43 VDD VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 4.1717e-21
C_2_44 VDD VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 4.7105e-21
C_2_45 VDD VSS:SiliconNXG29UTiSiXG30X1 2.8722e-21
C_2_46 VDD VSS:SiliconNXG519UTiSiXG530X1 2.8791e-21
C_2_47 VDD VSS:n1s 3.4462e-21
C_2_48 VDD VSS:n4d 3.4500e-21
C_2_49 VDD WLL 6.4518e-19
C_2_50 VDD WLR 6.4518e-19
C_2_51 VDD BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 8.6545e-19
C_2_52 VDD BLB:LM00Cobalt2XG71UTiSiXG73X1 1.0240e-19
C_2_53 VDD BLB:SiliconNXG72UTiSiXG73X1 7.8142e-21
C_2_54 VDD BLB:n3s 9.1229e-21
C_2_55 VDD BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 8.6924e-19
C_2_56 VDD BL:LM00Cobalt2XG535UTiSiXG524X1 1.0559e-19
C_2_57 VDD BL:SiliconNXG516UTiSiXG524X1 7.4356e-21
C_2_58 VDD BL:n2d 8.7310e-21
C_2_59 VDD WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.9810e-20
C_2_60 VDD WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 3.4922e-21
C_2_61 VDD WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.8995e-20
C_2_62 VDD WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 2.4118e-21
C_2_63 VDD WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 6.4647e-19
C_2_64 VDD WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 3.1144e-21
C_2_65 VDD WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 6.4606e-19
C_2_66 VDD WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 3.8487e-21
C_2_67 VDD WL:n2g 4.6024e-22
C_2_68 VDD WL:n3g 4.7914e-22
C_2_69 VDD iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 4.6701e-19
C_2_70 VDD iQ1:LM00Cobalt2XG308USiGeBXG285X1 2.1775e-19
C_2_71 VDD iQ1:LM00Cobalt2XG308UTiSiXG295X1 2.1735e-19
C_2_72 VDD iQ1:LM00Cobalt2XG308UTiSiXG296X1 2.1736e-19
C_2_73 VDD iQ1:SDexcludeXG264UTiSiXG296X1 2.3320e-22
C_2_74 VDD iQ1:SDexcludeXG271UTiSiXG295X1 6.3669e-23
C_2_75 VDD iQ1:SDexcludeXG272UTiSiXG295X1 7.7753e-23
C_2_76 VDD iQ1:SiGeBXG285UTiSiXG296X1 4.0499e-22
C_2_77 VDD iQ1:SiGeBXG286UTiSiXG296X1 8.9904e-24
C_2_78 VDD iQ1:SiGeBXG323UTiSiXG296X1 8.9543e-24
C_2_79 VDD iQ1:SiGeBXG327UTiSiXG296X1 8.9539e-24
C_2_80 VDD iQ1:SiliconNXG302UTiSiXG295X1 1.1153e-23
C_2_81 VDD iQ1:n1d 1.4777e-22
C_2_82 VDD iQ1:n2s 1.4777e-22
C_2_83 VDD iQ1:n4g 2.2710e-22
C_2_84 VDD iQ1:p1d 6.2028e-22
C_2_85 VDD iQ1:p2g 7.3920e-22
C_2_86 VDD iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 4.6849e-19
C_2_87 VDD iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.1810e-19
C_2_88 VDD iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.1771e-19
C_2_89 VDD iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.1770e-19
C_2_90 VDD iQ2:SDexcludeXG265UTiSiXG299X1 2.3590e-22
C_2_91 VDD iQ2:SDexcludeXG273UTiSiXG300X1 7.8255e-23
C_2_92 VDD iQ2:SDexcludeXG274UTiSiXG300X1 6.4245e-23
C_2_93 VDD iQ2:SiGeBXG288UTiSiXG299X1 4.0734e-22
C_2_94 VDD iQ2:SiGeBXG290UTiSiXG299X1 1.1440e-23
C_2_95 VDD iQ2:SiGeBXG328UTiSiXG299X1 1.1588e-23
C_2_96 VDD iQ2:SiliconNXG305UTiSiXG300X1 1.1613e-23
C_2_97 VDD iQ2:n1g 2.2664e-22
C_2_98 VDD iQ2:n3d 1.4908e-22
C_2_99 VDD iQ2:n4s 1.4908e-22
C_2_100 VDD iQ2:p1g 7.4583e-22
C_2_101 VDD iQ2:p2s 6.2038e-22
C_2_102 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS 1.3556e-18
C_2_103 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 3.9132e-20
C_2_104 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS:LM00Cobalt2XG21UTiSiXG30X1 3.6017e-20
C_2_105 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 4.5244e-19
C_2_106 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS:LM00Cobalt2XG539UTiSiXG530X1 4.5178e-19
C_2_107 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 4.5677e-21
C_2_108 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 4.6915e-21
C_2_109 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 4.9008e-21
C_2_110 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 7.8333e-21
C_2_111 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS:SiliconNXG29UTiSiXG30X1 3.0425e-21
C_2_112 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS:SiliconNXG519UTiSiXG530X1 8.1270e-20
C_2_113 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS:n1s 4.7821e-21
C_2_114 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VSS:n4d 8.8433e-20
C_2_115 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 WLL 6.4599e-19
C_2_116 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 WLR 6.4599e-19
C_2_117 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 9.4412e-19
C_2_118 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 1.0245e-19
C_2_119 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 BLB:SiliconNXG72UTiSiXG73X1 7.9996e-21
C_2_120 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 BLB:n3s 1.0546e-20
C_2_121 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 9.2280e-19
C_2_122 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 BL:LM00Cobalt2XG535UTiSiXG524X1 1.5262e-19
C_2_123 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 BL:SiliconNXG516UTiSiXG524X1 2.2978e-20
C_2_124 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 BL:n2d 3.0698e-20
C_2_125 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 2.0678e-20
C_2_126 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 3.5225e-21
C_2_127 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 3.1506e-20
C_2_128 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 2.7900e-21
C_2_129 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 6.4735e-19
C_2_130 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 3.3940e-21
C_2_131 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 6.4688e-19
C_2_132 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 3.8755e-21
C_2_133 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 WL:n2g 2.0986e-21
C_2_134 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 WL:n3g 1.0010e-21
C_2_135 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 2.6417e-18
C_2_136 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 2.5141e-19
C_2_137 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 2.5091e-19
C_2_138 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 2.5092e-19
C_2_139 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:SDexcludeXG264UTiSiXG296X1 9.7864e-22
C_2_140 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:SDexcludeXG271UTiSiXG295X1 3.0689e-22
C_2_141 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:SDexcludeXG272UTiSiXG295X1 3.8304e-22
C_2_142 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:SiGeBXG285UTiSiXG296X1 5.0670e-22
C_2_143 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:SiGeBXG286UTiSiXG296X1 9.9877e-24
C_2_144 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:SiGeBXG323UTiSiXG296X1 9.9419e-24
C_2_145 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:SiGeBXG327UTiSiXG296X1 9.9409e-24
C_2_146 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:SiliconNXG302UTiSiXG295X1 3.7348e-23
C_2_147 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:n1d 7.2091e-22
C_2_148 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:n2s 7.2091e-22
C_2_149 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:n4g 3.6881e-21
C_2_150 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:p1d 1.4655e-21
C_2_151 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ1:p2g 1.2945e-19
C_2_152 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 5.0363e-19
C_2_153 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.4812e-19
C_2_154 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.4764e-19
C_2_155 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.4763e-19
C_2_156 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:SDexcludeXG265UTiSiXG299X1 9.5970e-22
C_2_157 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:SDexcludeXG273UTiSiXG300X1 4.0003e-22
C_2_158 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:SDexcludeXG274UTiSiXG300X1 3.4104e-22
C_2_159 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:SiGeBXG288UTiSiXG299X1 5.1047e-22
C_2_160 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:SiGeBXG290UTiSiXG299X1 1.6121e-23
C_2_161 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:SiGeBXG328UTiSiXG299X1 1.6345e-23
C_2_162 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:SiliconNXG305UTiSiXG300X1 2.9105e-23
C_2_163 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:n1g 7.1656e-22
C_2_164 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:n3d 7.6273e-22
C_2_165 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:n4s 7.6273e-22
C_2_166 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:p1g 1.0514e-21
C_2_167 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 iQ2:p2s 1.4380e-21
C_2_168 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS 1.6107e-20
C_2_169 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 2.1045e-23
C_2_170 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS:LM00Cobalt2XG21UTiSiXG30X1 2.2215e-23
C_2_171 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 4.1639e-19
C_2_172 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS:LM00Cobalt2XG539UTiSiXG530X1 4.1907e-19
C_2_173 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 1.6642e-25
C_2_174 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 3.0139e-25
C_2_175 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 7.3381e-22
C_2_176 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 3.1516e-21
C_2_177 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS:SiliconNXG29UTiSiXG30X1 1.8003e-22
C_2_178 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS:SiliconNXG519UTiSiXG530X1 8.1736e-20
C_2_179 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS:n1s 1.4171e-21
C_2_180 VDD:LM00Cobalt2XG537UTiSiXG528X1 VSS:n4d 8.8938e-20
C_2_181 VDD:LM00Cobalt2XG537UTiSiXG528X1 WLL 8.2239e-22
C_2_182 VDD:LM00Cobalt2XG537UTiSiXG528X1 WLR 8.2239e-22
C_2_183 VDD:LM00Cobalt2XG537UTiSiXG528X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 7.8928e-20
C_2_184 VDD:LM00Cobalt2XG537UTiSiXG528X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 5.0067e-23
C_2_185 VDD:LM00Cobalt2XG537UTiSiXG528X1 BLB:SiliconNXG72UTiSiXG73X1 1.9750e-22
C_2_186 VDD:LM00Cobalt2XG537UTiSiXG528X1 BLB:n3s 1.5167e-21
C_2_187 VDD:LM00Cobalt2XG537UTiSiXG528X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 5.4366e-20
C_2_188 VDD:LM00Cobalt2XG537UTiSiXG528X1 BL:LM00Cobalt2XG535UTiSiXG524X1 4.7786e-20
C_2_189 VDD:LM00Cobalt2XG537UTiSiXG528X1 BL:SiliconNXG516UTiSiXG524X1 1.6016e-20
C_2_190 VDD:LM00Cobalt2XG537UTiSiXG528X1 BL:n2d 2.2749e-20
C_2_191 VDD:LM00Cobalt2XG537UTiSiXG528X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 9.2154e-22
C_2_192 VDD:LM00Cobalt2XG537UTiSiXG528X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 3.0434e-23
C_2_193 VDD:LM00Cobalt2XG537UTiSiXG528X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.2879e-20
C_2_194 VDD:LM00Cobalt2XG537UTiSiXG528X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 3.8389e-22
C_2_195 VDD:LM00Cobalt2XG537UTiSiXG528X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 8.8606e-22
C_2_196 VDD:LM00Cobalt2XG537UTiSiXG528X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 2.8312e-22
C_2_197 VDD:LM00Cobalt2XG537UTiSiXG528X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 8.2297e-22
C_2_198 VDD:LM00Cobalt2XG537UTiSiXG528X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 2.6859e-23
C_2_199 VDD:LM00Cobalt2XG537UTiSiXG528X1 WL:n2g 1.7151e-21
C_2_200 VDD:LM00Cobalt2XG537UTiSiXG528X1 WL:n3g 5.5659e-22
C_2_201 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 2.1889e-18
C_2_202 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 3.3784e-20
C_2_203 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 3.3683e-20
C_2_204 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 3.3683e-20
C_2_205 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:SDexcludeXG264UTiSiXG296X1 7.8942e-22
C_2_206 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:SDexcludeXG271UTiSiXG295X1 2.5747e-22
C_2_207 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:SDexcludeXG272UTiSiXG295X1 3.2287e-22
C_2_208 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:SiGeBXG285UTiSiXG296X1 1.0327e-22
C_2_209 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:SiGeBXG286UTiSiXG296X1 1.0001e-24
C_2_210 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:SiGeBXG323UTiSiXG296X1 9.9037e-25
C_2_211 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:SiGeBXG327UTiSiXG296X1 9.8964e-25
C_2_212 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:SiliconNXG302UTiSiXG295X1 2.7376e-23
C_2_213 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:n1d 6.0612e-22
C_2_214 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:n2s 6.0612e-22
C_2_215 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:n4g 3.6102e-21
C_2_216 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:p1d 8.9071e-22
C_2_217 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ1:p2g 1.3099e-19
C_2_218 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 3.5305e-20
C_2_219 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 3.0030e-20
C_2_220 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.9935e-20
C_2_221 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.9931e-20
C_2_222 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:SDexcludeXG265UTiSiXG299X1 7.7053e-22
C_2_223 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:SDexcludeXG273UTiSiXG300X1 3.4372e-22
C_2_224 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:SDexcludeXG274UTiSiXG300X1 2.9533e-22
C_2_225 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:SiGeBXG288UTiSiXG299X1 1.0415e-22
C_2_226 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:SiGeBXG290UTiSiXG299X1 4.6825e-24
C_2_227 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:SiGeBXG328UTiSiXG299X1 4.7587e-24
C_2_228 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:SiliconNXG305UTiSiXG300X1 1.8587e-23
C_2_229 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:n1g 5.1959e-22
C_2_230 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:n3d 6.5522e-22
C_2_231 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:n4s 6.5522e-22
C_2_232 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:p1g 3.2369e-22
C_2_233 VDD:LM00Cobalt2XG537UTiSiXG528X1 iQ2:p2s 8.6534e-22
C_2_234 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS 1.3552e-18
C_2_235 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 4.5069e-19
C_2_236 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS:LM00Cobalt2XG21UTiSiXG30X1 4.5012e-19
C_2_237 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 3.9595e-20
C_2_238 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS:LM00Cobalt2XG539UTiSiXG530X1 3.6415e-20
C_2_239 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 5.2898e-21
C_2_240 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 7.7462e-21
C_2_241 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 4.1719e-21
C_2_242 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 4.7108e-21
C_2_243 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS:SiliconNXG29UTiSiXG30X1 8.1186e-20
C_2_244 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS:SiliconNXG519UTiSiXG530X1 3.0379e-21
C_2_245 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS:n1s 8.8414e-20
C_2_246 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VSS:n4d 4.7769e-21
C_2_247 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 WLL 6.4599e-19
C_2_248 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 WLR 6.4599e-19
C_2_249 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 9.1676e-19
C_2_250 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 1.4716e-19
C_2_251 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 BLB:SiliconNXG72UTiSiXG73X1 2.3897e-20
C_2_252 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 BLB:n3s 3.1638e-20
C_2_253 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 9.4877e-19
C_2_254 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 BL:LM00Cobalt2XG535UTiSiXG524X1 1.0564e-19
C_2_255 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 BL:SiliconNXG516UTiSiXG524X1 7.6197e-21
C_2_256 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 BL:n2d 1.0148e-20
C_2_257 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 3.2910e-20
C_2_258 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 3.9866e-21
C_2_259 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.9861e-20
C_2_260 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 2.4553e-21
C_2_261 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 6.4729e-19
C_2_262 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 3.1548e-21
C_2_263 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 6.4691e-19
C_2_264 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 4.2211e-21
C_2_265 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 WL:n2g 9.8059e-22
C_2_266 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 WL:n3g 2.1417e-21
C_2_267 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 5.0142e-19
C_2_268 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 2.4778e-19
C_2_269 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 2.4729e-19
C_2_270 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 2.4730e-19
C_2_271 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:SDexcludeXG264UTiSiXG296X1 9.5724e-22
C_2_272 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:SDexcludeXG271UTiSiXG295X1 3.4021e-22
C_2_273 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:SDexcludeXG272UTiSiXG295X1 4.0004e-22
C_2_274 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:SiGeBXG285UTiSiXG296X1 5.0743e-22
C_2_275 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:SiGeBXG286UTiSiXG296X1 1.2775e-23
C_2_276 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:SiGeBXG323UTiSiXG296X1 1.2720e-23
C_2_277 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:SiGeBXG327UTiSiXG296X1 1.2719e-23
C_2_278 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:SiliconNXG302UTiSiXG295X1 2.8450e-23
C_2_279 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:n1d 7.6169e-22
C_2_280 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:n2s 7.6169e-22
C_2_281 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:n4g 7.1974e-22
C_2_282 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:p1d 1.4392e-21
C_2_283 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ1:p2g 1.0455e-21
C_2_284 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.6435e-18
C_2_285 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.5189e-19
C_2_286 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.5141e-19
C_2_287 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.5139e-19
C_2_288 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:SDexcludeXG265UTiSiXG299X1 9.8249e-22
C_2_289 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:SDexcludeXG273UTiSiXG300X1 3.8384e-22
C_2_290 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:SDexcludeXG274UTiSiXG300X1 3.0852e-22
C_2_291 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:SiGeBXG288UTiSiXG299X1 5.1007e-22
C_2_292 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:SiGeBXG290UTiSiXG299X1 1.2692e-23
C_2_293 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:SiGeBXG328UTiSiXG299X1 1.2839e-23
C_2_294 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:SiliconNXG305UTiSiXG300X1 3.8406e-23
C_2_295 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:n1g 3.6836e-21
C_2_296 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:n3d 7.2397e-22
C_2_297 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:n4s 7.2397e-22
C_2_298 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:p1g 1.2973e-19
C_2_299 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 iQ2:p2s 1.4672e-21
C_2_300 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS 1.5762e-20
C_2_301 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 4.1508e-19
C_2_302 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS:LM00Cobalt2XG21UTiSiXG30X1 4.1778e-19
C_2_303 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 1.9947e-23
C_2_304 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS:LM00Cobalt2XG539UTiSiXG530X1 2.1021e-23
C_2_305 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 7.2689e-22
C_2_306 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 3.0834e-21
C_2_307 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 2.1557e-25
C_2_308 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 3.4436e-25
C_2_309 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS:SiliconNXG29UTiSiXG30X1 8.1650e-20
C_2_310 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS:SiliconNXG519UTiSiXG530X1 1.6864e-22
C_2_311 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS:n1s 8.8920e-20
C_2_312 VDD:LM00Cobalt2XG58UTiSiXG60X1 VSS:n4d 1.4087e-21
C_2_313 VDD:LM00Cobalt2XG58UTiSiXG60X1 WLL 8.1952e-22
C_2_314 VDD:LM00Cobalt2XG58UTiSiXG60X1 WLR 8.1952e-22
C_2_315 VDD:LM00Cobalt2XG58UTiSiXG60X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 5.2071e-20
C_2_316 VDD:LM00Cobalt2XG58UTiSiXG60X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 4.5473e-20
C_2_317 VDD:LM00Cobalt2XG58UTiSiXG60X1 BLB:SiliconNXG72UTiSiXG73X1 1.6570e-20
C_2_318 VDD:LM00Cobalt2XG58UTiSiXG60X1 BLB:n3s 2.3311e-20
C_2_319 VDD:LM00Cobalt2XG58UTiSiXG60X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 7.9798e-20
C_2_320 VDD:LM00Cobalt2XG58UTiSiXG60X1 BL:LM00Cobalt2XG535UTiSiXG524X1 5.1621e-23
C_2_321 VDD:LM00Cobalt2XG58UTiSiXG60X1 BL:SiliconNXG516UTiSiXG524X1 1.9617e-22
C_2_322 VDD:LM00Cobalt2XG58UTiSiXG60X1 BL:n2d 1.5102e-21
C_2_323 VDD:LM00Cobalt2XG58UTiSiXG60X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.3479e-20
C_2_324 VDD:LM00Cobalt2XG58UTiSiXG60X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 5.0148e-22
C_2_325 VDD:LM00Cobalt2XG58UTiSiXG60X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 9.1950e-22
C_2_326 VDD:LM00Cobalt2XG58UTiSiXG60X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 4.3708e-23
C_2_327 VDD:LM00Cobalt2XG58UTiSiXG60X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 8.2009e-22
C_2_328 VDD:LM00Cobalt2XG58UTiSiXG60X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 4.0532e-23
C_2_329 VDD:LM00Cobalt2XG58UTiSiXG60X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 8.5006e-22
C_2_330 VDD:LM00Cobalt2XG58UTiSiXG60X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 3.7716e-22
C_2_331 VDD:LM00Cobalt2XG58UTiSiXG60X1 WL:n2g 5.5503e-22
C_2_332 VDD:LM00Cobalt2XG58UTiSiXG60X1 WL:n3g 1.7401e-21
C_2_333 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 3.4571e-20
C_2_334 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 3.0045e-20
C_2_335 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 2.9946e-20
C_2_336 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 2.9949e-20
C_2_337 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:SDexcludeXG264UTiSiXG296X1 7.7093e-22
C_2_338 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:SDexcludeXG271UTiSiXG295X1 2.9510e-22
C_2_339 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:SDexcludeXG272UTiSiXG295X1 3.4431e-22
C_2_340 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:SiGeBXG285UTiSiXG296X1 1.0347e-22
C_2_341 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:SiGeBXG286UTiSiXG296X1 3.7858e-24
C_2_342 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:SiGeBXG323UTiSiXG296X1 3.7668e-24
C_2_343 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:SiGeBXG327UTiSiXG296X1 3.7661e-24
C_2_344 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:SiliconNXG302UTiSiXG295X1 1.8386e-23
C_2_345 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:n1d 6.5559e-22
C_2_346 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:n2s 6.5559e-22
C_2_347 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:n4g 5.2250e-22
C_2_348 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:p1d 8.6687e-22
C_2_349 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ1:p2g 3.2452e-22
C_2_350 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.1892e-18
C_2_351 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 3.3921e-20
C_2_352 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 3.3819e-20
C_2_353 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 3.3818e-20
C_2_354 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:SDexcludeXG265UTiSiXG299X1 7.9072e-22
C_2_355 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:SDexcludeXG273UTiSiXG300X1 3.2322e-22
C_2_356 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:SDexcludeXG274UTiSiXG300X1 2.5860e-22
C_2_357 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:SiGeBXG288UTiSiXG299X1 1.0431e-22
C_2_358 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:SiGeBXG290UTiSiXG299X1 1.2546e-24
C_2_359 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:SiGeBXG328UTiSiXG299X1 1.2537e-24
C_2_360 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:SiliconNXG305UTiSiXG300X1 2.7994e-23
C_2_361 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:n1g 3.6071e-21
C_2_362 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:n3d 6.0801e-22
C_2_363 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:n4s 6.0801e-22
C_2_364 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:p1g 1.3124e-19
C_2_365 VDD:LM00Cobalt2XG58UTiSiXG60X1 iQ2:p2s 8.9254e-22
C_2_366 VDD:SiGeBXG512UTiSiXG528X1 VSS 8.1301e-22
C_2_367 VDD:SiGeBXG512UTiSiXG528X1 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 9.5938e-23
C_2_368 VDD:SiGeBXG512UTiSiXG528X1 VSS:LM00Cobalt2XG21UTiSiXG30X1 1.0232e-22
C_2_369 VDD:SiGeBXG512UTiSiXG528X1 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 5.0882e-20
C_2_370 VDD:SiGeBXG512UTiSiXG528X1 VSS:LM00Cobalt2XG539UTiSiXG530X1 5.3814e-20
C_2_371 VDD:SiGeBXG512UTiSiXG528X1 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 9.9778e-26
C_2_372 VDD:SiGeBXG512UTiSiXG528X1 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 1.3723e-24
C_2_373 VDD:SiGeBXG512UTiSiXG528X1 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 4.8711e-23
C_2_374 VDD:SiGeBXG512UTiSiXG528X1 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 3.4726e-22
C_2_375 VDD:SiGeBXG512UTiSiXG528X1 VSS:SiliconNXG29UTiSiXG30X1 9.3272e-22
C_2_376 VDD:SiGeBXG512UTiSiXG528X1 VSS:SiliconNXG519UTiSiXG530X1 1.5471e-19
C_2_377 VDD:SiGeBXG512UTiSiXG528X1 VSS:n1s 7.7002e-21
C_2_378 VDD:SiGeBXG512UTiSiXG528X1 VSS:n4d 2.2592e-19
C_2_379 VDD:SiGeBXG512UTiSiXG528X1 WLL 3.9962e-23
C_2_380 VDD:SiGeBXG512UTiSiXG528X1 WLR 3.9962e-23
C_2_381 VDD:SiGeBXG512UTiSiXG528X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 2.5983e-21
C_2_382 VDD:SiGeBXG512UTiSiXG528X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 1.3029e-22
C_2_383 VDD:SiGeBXG512UTiSiXG528X1 BLB:SiliconNXG72UTiSiXG73X1 1.2052e-21
C_2_384 VDD:SiGeBXG512UTiSiXG528X1 BLB:n3s 9.3480e-21
C_2_385 VDD:SiGeBXG512UTiSiXG528X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 1.6435e-20
C_2_386 VDD:SiGeBXG512UTiSiXG528X1 BL:LM00Cobalt2XG535UTiSiXG524X1 1.5853e-20
C_2_387 VDD:SiGeBXG512UTiSiXG528X1 BL:SiliconNXG516UTiSiXG524X1 1.7390e-20
C_2_388 VDD:SiGeBXG512UTiSiXG528X1 BL:n2d 3.7897e-20
C_2_389 VDD:SiGeBXG512UTiSiXG528X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 5.4487e-21
C_2_390 VDD:SiGeBXG512UTiSiXG528X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 9.1453e-24
C_2_391 VDD:SiGeBXG512UTiSiXG528X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.7828e-20
C_2_392 VDD:SiGeBXG512UTiSiXG528X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 1.2707e-22
C_2_393 VDD:SiGeBXG512UTiSiXG528X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 5.1685e-23
C_2_394 VDD:SiGeBXG512UTiSiXG528X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 6.8369e-23
C_2_395 VDD:SiGeBXG512UTiSiXG528X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 4.0041e-23
C_2_396 VDD:SiGeBXG512UTiSiXG528X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 3.5782e-24
C_2_397 VDD:SiGeBXG512UTiSiXG528X1 WL:n2g 7.6729e-23
C_2_398 VDD:SiGeBXG512UTiSiXG528X1 WL:n3g 3.4722e-23
C_2_399 VDD:SiGeBXG512UTiSiXG528X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 1.6870e-18
C_2_400 VDD:SiGeBXG512UTiSiXG528X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 2.0273e-21
C_2_401 VDD:SiGeBXG512UTiSiXG528X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.9135e-21
C_2_402 VDD:SiGeBXG512UTiSiXG528X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.9133e-21
C_2_403 VDD:SiGeBXG512UTiSiXG528X1 iQ1:SDexcludeXG264UTiSiXG296X1 4.1813e-21
C_2_404 VDD:SiGeBXG512UTiSiXG528X1 iQ1:SDexcludeXG271UTiSiXG295X1 1.2841e-21
C_2_405 VDD:SiGeBXG512UTiSiXG528X1 iQ1:SDexcludeXG272UTiSiXG295X1 1.5577e-21
C_2_406 VDD:SiGeBXG512UTiSiXG528X1 iQ1:SiGeBXG285UTiSiXG296X1 1.1422e-22
C_2_407 VDD:SiGeBXG512UTiSiXG528X1 iQ1:SiGeBXG286UTiSiXG296X1 8.2655e-26
C_2_408 VDD:SiGeBXG512UTiSiXG528X1 iQ1:SiGeBXG323UTiSiXG296X1 7.5035e-26
C_2_409 VDD:SiGeBXG512UTiSiXG528X1 iQ1:SiGeBXG327UTiSiXG296X1 7.1298e-26
C_2_410 VDD:SiGeBXG512UTiSiXG528X1 iQ1:SiliconNXG302UTiSiXG295X1 8.8273e-23
C_2_411 VDD:SiGeBXG512UTiSiXG528X1 iQ1:n1d 2.9292e-21
C_2_412 VDD:SiGeBXG512UTiSiXG528X1 iQ1:n2s 2.9292e-21
C_2_413 VDD:SiGeBXG512UTiSiXG528X1 iQ1:n4g 1.4927e-22
C_2_414 VDD:SiGeBXG512UTiSiXG528X1 iQ1:p1d 4.2954e-21
C_2_415 VDD:SiGeBXG512UTiSiXG528X1 iQ1:p2g 2.2821e-21
C_2_416 VDD:SiGeBXG512UTiSiXG528X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.2592e-20
C_2_417 VDD:SiGeBXG512UTiSiXG528X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.0328e-22
C_2_418 VDD:SiGeBXG512UTiSiXG528X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 9.3945e-23
C_2_419 VDD:SiGeBXG512UTiSiXG528X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 9.4133e-23
C_2_420 VDD:SiGeBXG512UTiSiXG528X1 iQ2:SDexcludeXG265UTiSiXG299X1 5.3173e-21
C_2_421 VDD:SiGeBXG512UTiSiXG528X1 iQ2:SDexcludeXG273UTiSiXG300X1 2.2987e-21
C_2_422 VDD:SiGeBXG512UTiSiXG528X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.8218e-21
C_2_423 VDD:SiGeBXG512UTiSiXG528X1 iQ2:SiGeBXG288UTiSiXG299X1 1.0939e-22
C_2_424 VDD:SiGeBXG512UTiSiXG528X1 iQ2:SiGeBXG290UTiSiXG299X1 2.8236e-26
C_2_425 VDD:SiGeBXG512UTiSiXG528X1 iQ2:SiGeBXG328UTiSiXG299X1 2.6086e-26
C_2_426 VDD:SiGeBXG512UTiSiXG528X1 iQ2:SiliconNXG305UTiSiXG300X1 1.0899e-22
C_2_427 VDD:SiGeBXG512UTiSiXG528X1 iQ2:n1g 2.9669e-23
C_2_428 VDD:SiGeBXG512UTiSiXG528X1 iQ2:n3d 4.2288e-21
C_2_429 VDD:SiGeBXG512UTiSiXG528X1 iQ2:n4s 4.2288e-21
C_2_430 VDD:SiGeBXG512UTiSiXG528X1 iQ2:p1g 1.8160e-23
C_2_431 VDD:SiGeBXG512UTiSiXG528X1 iQ2:p2s 5.4266e-21
C_2_432 VDD:SiGeBXG59UTiSiXG60X1 VSS 7.9446e-22
C_2_433 VDD:SiGeBXG59UTiSiXG60X1 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 5.0886e-20
C_2_434 VDD:SiGeBXG59UTiSiXG60X1 VSS:LM00Cobalt2XG21UTiSiXG30X1 5.3785e-20
C_2_435 VDD:SiGeBXG59UTiSiXG60X1 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 9.6160e-23
C_2_436 VDD:SiGeBXG59UTiSiXG60X1 VSS:LM00Cobalt2XG539UTiSiXG530X1 1.0258e-22
C_2_437 VDD:SiGeBXG59UTiSiXG60X1 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 4.8393e-23
C_2_438 VDD:SiGeBXG59UTiSiXG60X1 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 3.4408e-22
C_2_439 VDD:SiGeBXG59UTiSiXG60X1 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 1.2700e-25
C_2_440 VDD:SiGeBXG59UTiSiXG60X1 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 1.4220e-24
C_2_441 VDD:SiGeBXG59UTiSiXG60X1 VSS:SiliconNXG29UTiSiXG30X1 1.5420e-19
C_2_442 VDD:SiGeBXG59UTiSiXG60X1 VSS:SiliconNXG519UTiSiXG530X1 9.3408e-22
C_2_443 VDD:SiGeBXG59UTiSiXG60X1 VSS:n1s 2.2556e-19
C_2_444 VDD:SiGeBXG59UTiSiXG60X1 VSS:n4d 7.7201e-21
C_2_445 VDD:SiGeBXG59UTiSiXG60X1 WLL 3.9801e-23
C_2_446 VDD:SiGeBXG59UTiSiXG60X1 WLR 3.9801e-23
C_2_447 VDD:SiGeBXG59UTiSiXG60X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 1.5495e-20
C_2_448 VDD:SiGeBXG59UTiSiXG60X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 1.4919e-20
C_2_449 VDD:SiGeBXG59UTiSiXG60X1 BLB:SiliconNXG72UTiSiXG73X1 1.7702e-20
C_2_450 VDD:SiGeBXG59UTiSiXG60X1 BLB:n3s 3.8186e-20
C_2_451 VDD:SiGeBXG59UTiSiXG60X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 2.6375e-21
C_2_452 VDD:SiGeBXG59UTiSiXG60X1 BL:LM00Cobalt2XG535UTiSiXG524X1 1.3520e-22
C_2_453 VDD:SiGeBXG59UTiSiXG60X1 BL:SiliconNXG516UTiSiXG524X1 1.1943e-21
C_2_454 VDD:SiGeBXG59UTiSiXG60X1 BL:n2d 9.2795e-21
C_2_455 VDD:SiGeBXG59UTiSiXG60X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.7994e-20
C_2_456 VDD:SiGeBXG59UTiSiXG60X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.5466e-22
C_2_457 VDD:SiGeBXG59UTiSiXG60X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 5.4253e-21
C_2_458 VDD:SiGeBXG59UTiSiXG60X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 8.7780e-24
C_2_459 VDD:SiGeBXG59UTiSiXG60X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 4.0068e-23
C_2_460 VDD:SiGeBXG59UTiSiXG60X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 3.3060e-24
C_2_461 VDD:SiGeBXG59UTiSiXG60X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 4.4782e-23
C_2_462 VDD:SiGeBXG59UTiSiXG60X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 9.2238e-23
C_2_463 VDD:SiGeBXG59UTiSiXG60X1 WL:n2g 3.4677e-23
C_2_464 VDD:SiGeBXG59UTiSiXG60X1 WL:n3g 7.7551e-23
C_2_465 VDD:SiGeBXG59UTiSiXG60X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 1.2556e-20
C_2_466 VDD:SiGeBXG59UTiSiXG60X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 2.0288e-22
C_2_467 VDD:SiGeBXG59UTiSiXG60X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 9.4198e-23
C_2_468 VDD:SiGeBXG59UTiSiXG60X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 9.4163e-23
C_2_469 VDD:SiGeBXG59UTiSiXG60X1 iQ1:SDexcludeXG264UTiSiXG296X1 5.3087e-21
C_2_470 VDD:SiGeBXG59UTiSiXG60X1 iQ1:SDexcludeXG271UTiSiXG295X1 1.8160e-21
C_2_471 VDD:SiGeBXG59UTiSiXG60X1 iQ1:SDexcludeXG272UTiSiXG295X1 2.2968e-21
C_2_472 VDD:SiGeBXG59UTiSiXG60X1 iQ1:SiGeBXG285UTiSiXG296X1 1.0876e-22
C_2_473 VDD:SiGeBXG59UTiSiXG60X1 iQ1:SiGeBXG286UTiSiXG296X1 2.6349e-26
C_2_474 VDD:SiGeBXG59UTiSiXG60X1 iQ1:SiGeBXG323UTiSiXG296X1 2.7655e-26
C_2_475 VDD:SiGeBXG59UTiSiXG60X1 iQ1:SiGeBXG327UTiSiXG296X1 2.3800e-26
C_2_476 VDD:SiGeBXG59UTiSiXG60X1 iQ1:SiliconNXG302UTiSiXG295X1 1.0810e-22
C_2_477 VDD:SiGeBXG59UTiSiXG60X1 iQ1:n1d 4.2206e-21
C_2_478 VDD:SiGeBXG59UTiSiXG60X1 iQ1:n2s 4.2206e-21
C_2_479 VDD:SiGeBXG59UTiSiXG60X1 iQ1:n4g 2.9869e-23
C_2_480 VDD:SiGeBXG59UTiSiXG60X1 iQ1:p1d 5.4174e-21
C_2_481 VDD:SiGeBXG59UTiSiXG60X1 iQ1:p2g 1.8231e-23
C_2_482 VDD:SiGeBXG59UTiSiXG60X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.6822e-18
C_2_483 VDD:SiGeBXG59UTiSiXG60X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.0568e-21
C_2_484 VDD:SiGeBXG59UTiSiXG60X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 1.9425e-21
C_2_485 VDD:SiGeBXG59UTiSiXG60X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 1.9428e-21
C_2_486 VDD:SiGeBXG59UTiSiXG60X1 iQ2:SDexcludeXG265UTiSiXG299X1 4.1700e-21
C_2_487 VDD:SiGeBXG59UTiSiXG60X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.5538e-21
C_2_488 VDD:SiGeBXG59UTiSiXG60X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.2853e-21
C_2_489 VDD:SiGeBXG59UTiSiXG60X1 iQ2:SiGeBXG288UTiSiXG299X1 1.1443e-22
C_2_490 VDD:SiGeBXG59UTiSiXG60X1 iQ2:SiGeBXG290UTiSiXG299X1 8.8068e-26
C_2_491 VDD:SiGeBXG59UTiSiXG60X1 iQ2:SiGeBXG328UTiSiXG299X1 8.0481e-26
C_2_492 VDD:SiGeBXG59UTiSiXG60X1 iQ2:SiliconNXG305UTiSiXG300X1 8.8889e-23
C_2_493 VDD:SiGeBXG59UTiSiXG60X1 iQ2:n1g 1.5011e-22
C_2_494 VDD:SiGeBXG59UTiSiXG60X1 iQ2:n3d 2.9268e-21
C_2_495 VDD:SiGeBXG59UTiSiXG60X1 iQ2:n4s 2.9268e-21
C_2_496 VDD:SiGeBXG59UTiSiXG60X1 iQ2:p1g 2.2645e-21
C_2_497 VDD:SiGeBXG59UTiSiXG60X1 iQ2:p2s 4.2842e-21
C_2_498 VDD:p1s VSS 8.6955e-22
C_2_499 VDD:p1s VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 5.5713e-20
C_2_500 VDD:p1s VSS:LM00Cobalt2XG21UTiSiXG30X1 5.9068e-20
C_2_501 VDD:p1s VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 6.5775e-22
C_2_502 VDD:p1s VSS:LM00Cobalt2XG539UTiSiXG530X1 7.0184e-22
C_2_503 VDD:p1s VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 5.3382e-23
C_2_504 VDD:p1s VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 4.0485e-22
C_2_505 VDD:p1s VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 7.6878e-25
C_2_506 VDD:p1s VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 9.6400e-24
C_2_507 VDD:p1s VSS:SiliconNXG29UTiSiXG30X1 2.2004e-19
C_2_508 VDD:p1s VSS:SiliconNXG519UTiSiXG530X1 6.3664e-21
C_2_509 VDD:p1s VSS:n1s 4.9653e-19
C_2_510 VDD:p1s VSS:n4d 5.2106e-20
C_2_511 VDD:p1s WLL 4.3199e-23
C_2_512 VDD:p1s WLR 4.3199e-23
C_2_513 VDD:p1s BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 2.0686e-20
C_2_514 VDD:p1s BLB:LM00Cobalt2XG71UTiSiXG73X1 2.0118e-20
C_2_515 VDD:p1s BLB:SiliconNXG72UTiSiXG73X1 3.6767e-20
C_2_516 VDD:p1s BLB:n3s 1.2279e-19
C_2_517 VDD:p1s BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 3.6067e-21
C_2_518 VDD:p1s BL:LM00Cobalt2XG535UTiSiXG524X1 9.9350e-22
C_2_519 VDD:p1s BL:SiliconNXG516UTiSiXG524X1 8.6979e-21
C_2_520 VDD:p1s BL:n2d 6.7504e-20
C_2_521 VDD:p1s WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 5.9498e-20
C_2_522 VDD:p1s WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 2.6347e-22
C_2_523 VDD:p1s WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 4.1170e-20
C_2_524 VDD:p1s WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 5.6276e-23
C_2_525 VDD:p1s WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 4.4897e-23
C_2_526 VDD:p1s WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.6924e-23
C_2_527 VDD:p1s WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 4.9723e-23
C_2_528 VDD:p1s WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.3910e-22
C_2_529 VDD:p1s iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 9.5014e-20
C_2_530 VDD:p1s iQ1:LM00Cobalt2XG308USiGeBXG285X1 1.4448e-21
C_2_531 VDD:p1s iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.7735e-22
C_2_532 VDD:p1s iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.7721e-22
C_2_533 VDD:p1s iQ1:SDexcludeXG264UTiSiXG296X1 1.4228e-19
C_2_534 VDD:p1s iQ1:SDexcludeXG271UTiSiXG295X1 1.2412e-20
C_2_535 VDD:p1s iQ1:SDexcludeXG272UTiSiXG295X1 1.7782e-20
C_2_536 VDD:p1s iQ1:SiGeBXG285UTiSiXG296X1 1.2679e-21
C_2_537 VDD:p1s iQ1:SiGeBXG286UTiSiXG296X1 1.8603e-25
C_2_538 VDD:p1s iQ1:SiGeBXG323UTiSiXG296X1 1.8410e-25
C_2_539 VDD:p1s iQ1:SiGeBXG327UTiSiXG296X1 1.6128e-25
C_2_540 VDD:p1s iQ1:SiliconNXG302UTiSiXG295X1 8.6005e-22
C_2_541 VDD:p1s iQ1:n1d 3.1053e-20
C_2_542 VDD:p1s iQ1:n2s 3.1053e-20
C_2_543 VDD:p1s iQ1:p1d 1.4355e-19
C_2_544 VDD:p1s iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 3.7078e-18
C_2_545 VDD:p1s iQ2:LM00Cobalt2XG153USiGeBXG288X1 3.0228e-21
C_2_546 VDD:p1s iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.2626e-21
C_2_547 VDD:p1s iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.2635e-21
C_2_548 VDD:p1s iQ2:SDexcludeXG265UTiSiXG299X1 2.9034e-20
C_2_549 VDD:p1s iQ2:SDexcludeXG273UTiSiXG300X1 9.5631e-21
C_2_550 VDD:p1s iQ2:SDexcludeXG274UTiSiXG300X1 8.1210e-21
C_2_551 VDD:p1s iQ2:SiGeBXG288UTiSiXG299X1 7.6047e-22
C_2_552 VDD:p1s iQ2:SiGeBXG290UTiSiXG299X1 1.5325e-25
C_2_553 VDD:p1s iQ2:SiGeBXG328UTiSiXG299X1 1.2455e-25
C_2_554 VDD:p1s iQ2:SiliconNXG305UTiSiXG300X1 4.9811e-22
C_2_555 VDD:p1s iQ2:n3d 1.8179e-20
C_2_556 VDD:p1s iQ2:n4s 1.8179e-20
C_2_557 VDD:p1s iQ2:p2s 2.9795e-20
C_2_558 VDD:p2d VSS 8.8909e-22
C_2_559 VDD:p2d VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 6.5523e-22
C_2_560 VDD:p2d VSS:LM00Cobalt2XG21UTiSiXG30X1 6.9891e-22
C_2_561 VDD:p2d VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 5.5644e-20
C_2_562 VDD:p2d VSS:LM00Cobalt2XG539UTiSiXG530X1 5.9036e-20
C_2_563 VDD:p2d VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 7.1037e-25
C_2_564 VDD:p2d VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 9.4519e-24
C_2_565 VDD:p2d VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 5.3399e-23
C_2_566 VDD:p2d VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 4.0787e-22
C_2_567 VDD:p2d VSS:SiliconNXG29UTiSiXG30X1 6.3481e-21
C_2_568 VDD:p2d VSS:SiliconNXG519UTiSiXG530X1 2.2033e-19
C_2_569 VDD:p2d VSS:n1s 5.1894e-20
C_2_570 VDD:p2d VSS:n4d 4.9627e-19
C_2_571 VDD:p2d WLL 4.3510e-23
C_2_572 VDD:p2d WLR 4.3510e-23
C_2_573 VDD:p2d BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 3.5283e-21
C_2_574 VDD:p2d BLB:LM00Cobalt2XG71UTiSiXG73X1 9.5528e-22
C_2_575 VDD:p2d BLB:SiliconNXG72UTiSiXG73X1 8.7593e-21
C_2_576 VDD:p2d BLB:n3s 6.7860e-20
C_2_577 VDD:p2d BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 2.1936e-20
C_2_578 VDD:p2d BL:LM00Cobalt2XG535UTiSiXG524X1 2.1358e-20
C_2_579 VDD:p2d BL:SiliconNXG516UTiSiXG524X1 3.6309e-20
C_2_580 VDD:p2d BL:n2d 1.2229e-19
C_2_581 VDD:p2d WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 4.1268e-20
C_2_582 VDD:p2d WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 6.1603e-23
C_2_583 VDD:p2d WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 5.9317e-20
C_2_584 VDD:p2d WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 2.2279e-22
C_2_585 VDD:p2d WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 5.9716e-23
C_2_586 VDD:p2d WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.0305e-22
C_2_587 VDD:p2d WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 4.3942e-23
C_2_588 VDD:p2d WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 2.1841e-23
C_2_589 VDD:p2d iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 3.7053e-18
C_2_590 VDD:p2d iQ1:LM00Cobalt2XG308USiGeBXG285X1 2.9838e-21
C_2_591 VDD:p2d iQ1:LM00Cobalt2XG308UTiSiXG295X1 2.2254e-21
C_2_592 VDD:p2d iQ1:LM00Cobalt2XG308UTiSiXG296X1 2.2250e-21
C_2_593 VDD:p2d iQ1:SDexcludeXG264UTiSiXG296X1 2.9064e-20
C_2_594 VDD:p2d iQ1:SDexcludeXG271UTiSiXG295X1 8.0958e-21
C_2_595 VDD:p2d iQ1:SDexcludeXG272UTiSiXG295X1 9.5671e-21
C_2_596 VDD:p2d iQ1:SiGeBXG285UTiSiXG296X1 7.5906e-22
C_2_597 VDD:p2d iQ1:SiGeBXG286UTiSiXG296X1 1.6984e-25
C_2_598 VDD:p2d iQ1:SiGeBXG323UTiSiXG296X1 1.5111e-25
C_2_599 VDD:p2d iQ1:SiGeBXG327UTiSiXG296X1 1.2877e-25
C_2_600 VDD:p2d iQ1:SiliconNXG302UTiSiXG295X1 4.9453e-22
C_2_601 VDD:p2d iQ1:n1d 1.8156e-20
C_2_602 VDD:p2d iQ1:n2s 1.8156e-20
C_2_603 VDD:p2d iQ1:p1d 2.9823e-20
C_2_604 VDD:p2d iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 9.5134e-20
C_2_605 VDD:p2d iQ2:LM00Cobalt2XG153USiGeBXG288X1 1.4482e-21
C_2_606 VDD:p2d iQ2:LM00Cobalt2XG153UTiSiXG299X1 1.7579e-22
C_2_607 VDD:p2d iQ2:LM00Cobalt2XG153UTiSiXG300X1 1.7671e-22
C_2_608 VDD:p2d iQ2:SDexcludeXG265UTiSiXG299X1 1.4233e-19
C_2_609 VDD:p2d iQ2:SDexcludeXG273UTiSiXG300X1 1.7761e-20
C_2_610 VDD:p2d iQ2:SDexcludeXG274UTiSiXG300X1 1.2434e-20
C_2_611 VDD:p2d iQ2:SiGeBXG288UTiSiXG299X1 1.2727e-21
C_2_612 VDD:p2d iQ2:SiGeBXG290UTiSiXG299X1 1.8210e-25
C_2_613 VDD:p2d iQ2:SiGeBXG328UTiSiXG299X1 1.6119e-25
C_2_614 VDD:p2d iQ2:SiliconNXG305UTiSiXG300X1 8.6530e-22
C_2_615 VDD:p2d iQ2:n3d 3.1057e-20
C_2_616 VDD:p2d iQ2:n4s 3.1057e-20
C_2_617 VDD:p2d iQ2:p2s 1.4360e-19
R_2_0 VDD VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 5.2168e+01
R_2_1 VDD VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 5.0764e+01
R_2_2 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VDD:LM00Cobalt2XG537UTiSiXG528X1 8.5106e+01
R_2_3 VDD:LM00Cobalt2XG537ULM40Cobalt5XG64X1 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 1.1805e+03
R_2_4 VDD:LM00Cobalt2XG537UTiSiXG528X1 VDD:SiGeBXG512UTiSiXG528X1 2.6033e+02
R_2_5 VDD:LM00Cobalt2XG58ULM40Cobalt5XG64X1 VDD:LM00Cobalt2XG58UTiSiXG60X1 8.5106e+01
R_2_6 VDD:LM00Cobalt2XG58UTiSiXG60X1 VDD:SiGeBXG59UTiSiXG60X1 2.5777e+02
R_2_7 VDD:SiGeBXG512UTiSiXG528X1 VDD:p2d 3.7343e+01
R_2_8 VDD:SiGeBXG59UTiSiXG60X1 VDD:p1s 3.5756e+01

*|NET VSS 8.6797e-05PF
C_3_0 BLBD VSS 8.0355e-19
C_3_1 BLBD VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 2.6691e-22
C_3_2 BLBD VSS:LM00Cobalt2XG21UTiSiXG30X1 2.5750e-22
C_3_3 BLBD VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 9.2320e-19
C_3_4 BLBD VSS:LM00Cobalt2XG539UTiSiXG530X1 3.6418e-19
C_3_5 BLBD VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 2.7487e-23
C_3_6 BLBD VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 2.0187e-23
C_3_7 BLBD VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 1.4782e-19
C_3_8 BLBD VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 6.3679e-19
C_3_9 BLBD VSS:SiliconNXG29UTiSiXG30X1 1.0874e-22
C_3_10 BLBD VSS:SiliconNXG519UTiSiXG530X1 9.5564e-21
C_3_11 BLBD VSS:n1s 2.2417e-22
C_3_12 BLBD VSS:n4d 9.6987e-21
C_3_13 BLBU VSS 8.0355e-19
C_3_14 BLBU VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 2.6691e-22
C_3_15 BLBU VSS:LM00Cobalt2XG21UTiSiXG30X1 2.5750e-22
C_3_16 BLBU VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 9.2320e-19
C_3_17 BLBU VSS:LM00Cobalt2XG539UTiSiXG530X1 3.6418e-19
C_3_18 BLBU VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 2.7487e-23
C_3_19 BLBU VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 2.0187e-23
C_3_20 BLBU VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 1.4782e-19
C_3_21 BLBU VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 6.3679e-19
C_3_22 BLBU VSS:SiliconNXG29UTiSiXG30X1 1.0874e-22
C_3_23 BLBU VSS:SiliconNXG519UTiSiXG530X1 9.5564e-21
C_3_24 BLBU VSS:n1s 2.2417e-22
C_3_25 BLBU VSS:n4d 9.6987e-21
C_3_26 BLD VSS 8.1372e-19
C_3_27 BLD VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 8.6320e-19
C_3_28 BLD VSS:LM00Cobalt2XG21UTiSiXG30X1 3.6663e-19
C_3_29 BLD VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 2.6611e-22
C_3_30 BLD VSS:LM00Cobalt2XG539UTiSiXG530X1 2.5666e-22
C_3_31 BLD VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 1.5206e-19
C_3_32 BLD VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 5.7550e-19
C_3_33 BLD VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 2.4545e-23
C_3_34 BLD VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 1.9965e-23
C_3_35 BLD VSS:SiliconNXG29UTiSiXG30X1 9.6403e-21
C_3_36 BLD VSS:SiliconNXG519UTiSiXG530X1 1.0795e-22
C_3_37 BLD VSS:n1s 9.7859e-21
C_3_38 BLD VSS:n4d 2.2378e-22
C_3_39 BLU VSS 8.1372e-19
C_3_40 BLU VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 8.6320e-19
C_3_41 BLU VSS:LM00Cobalt2XG21UTiSiXG30X1 3.6663e-19
C_3_42 BLU VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 2.6611e-22
C_3_43 BLU VSS:LM00Cobalt2XG539UTiSiXG530X1 2.5666e-22
C_3_44 BLU VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 1.5206e-19
C_3_45 BLU VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 5.7550e-19
C_3_46 BLU VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 2.4545e-23
C_3_47 BLU VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 1.9965e-23
C_3_48 BLU VSS:SiliconNXG29UTiSiXG30X1 9.6403e-21
C_3_49 BLU VSS:SiliconNXG519UTiSiXG530X1 1.0795e-22
C_3_50 BLU VSS:n1s 9.7859e-21
C_3_51 BLU VSS:n4d 2.2378e-22
C_3_52 VSS WLL 4.0426e-18
C_3_53 VSS WLR 4.0426e-18
C_3_54 VSS BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 8.3125e-19
C_3_55 VSS BLB:LM00Cobalt2XG71UTiSiXG73X1 2.7864e-20
C_3_56 VSS BLB:SiliconNXG72UTiSiXG73X1 3.1522e-21
C_3_57 VSS BLB:n3s 3.3787e-21
C_3_58 VSS BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 8.4517e-19
C_3_59 VSS BL:LM00Cobalt2XG535UTiSiXG524X1 3.1623e-20
C_3_60 VSS BL:SiliconNXG516UTiSiXG524X1 3.6466e-21
C_3_61 VSS BL:n2d 3.9019e-21
C_3_62 VSS WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 5.2620e-21
C_3_63 VSS WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.6271e-19
C_3_64 VSS WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 7.4040e-21
C_3_65 VSS WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 8.1053e-20
C_3_66 VSS WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 4.3545e-18
C_3_67 VSS WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 3.8746e-19
C_3_68 VSS WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 4.2848e-18
C_3_69 VSS WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 4.0133e-19
C_3_70 VSS WL:n2g 1.2032e-22
C_3_71 VSS WL:n3g 1.0582e-22
C_3_72 VSS iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 5.4391e-21
C_3_73 VSS iQ1:LM00Cobalt2XG308USiGeBXG285X1 7.9423e-22
C_3_74 VSS iQ1:LM00Cobalt2XG308UTiSiXG295X1 7.9307e-22
C_3_75 VSS iQ1:LM00Cobalt2XG308UTiSiXG296X1 7.9304e-22
C_3_76 VSS iQ1:SDexcludeXG264UTiSiXG296X1 1.9586e-23
C_3_77 VSS iQ1:SDexcludeXG271UTiSiXG295X1 1.0361e-23
C_3_78 VSS iQ1:SDexcludeXG272UTiSiXG295X1 1.0613e-23
C_3_79 VSS iQ1:SiGeBXG285UTiSiXG296X1 1.2069e-24
C_3_80 VSS iQ1:SiGeBXG286UTiSiXG296X1 1.0823e-26
C_3_81 VSS iQ1:SiGeBXG323UTiSiXG296X1 1.0547e-26
C_3_82 VSS iQ1:SiGeBXG327UTiSiXG296X1 1.0523e-26
C_3_83 VSS iQ1:SiliconNXG302UTiSiXG295X1 9.5952e-25
C_3_84 VSS iQ1:n1d 2.1812e-23
C_3_85 VSS iQ1:n2s 2.1812e-23
C_3_86 VSS iQ1:n4g 3.4977e-23
C_3_87 VSS iQ1:p1d 2.0772e-23
C_3_88 VSS iQ1:p2g 3.3189e-23
C_3_89 VSS iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 5.3846e-21
C_3_90 VSS iQ2:LM00Cobalt2XG153USiGeBXG288X1 7.8285e-22
C_3_91 VSS iQ2:LM00Cobalt2XG153UTiSiXG299X1 7.8163e-22
C_3_92 VSS iQ2:LM00Cobalt2XG153UTiSiXG300X1 7.8166e-22
C_3_93 VSS iQ2:SDexcludeXG265UTiSiXG299X1 1.9459e-23
C_3_94 VSS iQ2:SDexcludeXG273UTiSiXG300X1 1.0369e-23
C_3_95 VSS iQ2:SDexcludeXG274UTiSiXG300X1 1.0005e-23
C_3_96 VSS iQ2:SiGeBXG288UTiSiXG299X1 1.2429e-24
C_3_97 VSS iQ2:SiGeBXG290UTiSiXG299X1 1.3164e-26
C_3_98 VSS iQ2:SiGeBXG328UTiSiXG299X1 1.2665e-26
C_3_99 VSS iQ2:SiliconNXG305UTiSiXG300X1 9.7196e-25
C_3_100 VSS iQ2:n1g 3.4359e-23
C_3_101 VSS iQ2:n3d 2.1203e-23
C_3_102 VSS iQ2:n4s 2.1203e-23
C_3_103 VSS iQ2:p1g 3.3207e-23
C_3_104 VSS iQ2:p2s 2.0677e-23
C_3_105 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 WLL 2.6244e-20
C_3_106 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 WLR 2.6244e-20
C_3_107 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 1.5837e-21
C_3_108 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 1.3426e-21
C_3_109 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 BLB:SiliconNXG72UTiSiXG73X1 8.1814e-22
C_3_110 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 BLB:n3s 2.1327e-21
C_3_111 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 8.6333e-19
C_3_112 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 BL:LM00Cobalt2XG535UTiSiXG524X1 1.3031e-22
C_3_113 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 BL:SiliconNXG516UTiSiXG524X1 2.2300e-22
C_3_114 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 BL:n2d 1.8177e-21
C_3_115 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.0512e-21
C_3_116 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.8410e-23
C_3_117 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 7.4970e-21
C_3_118 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 5.4314e-19
C_3_119 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 3.3772e-20
C_3_120 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 5.4697e-19
C_3_121 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 2.6245e-20
C_3_122 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.3955e-23
C_3_123 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 WL:n2g 8.2288e-22
C_3_124 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 WL:n3g 4.2279e-22
C_3_125 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 8.8774e-20
C_3_126 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 8.6747e-20
C_3_127 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 8.6835e-20
C_3_128 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 8.6733e-20
C_3_129 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:SDexcludeXG264UTiSiXG296X1 5.3507e-22
C_3_130 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:SDexcludeXG271UTiSiXG295X1 8.9670e-22
C_3_131 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:SDexcludeXG272UTiSiXG295X1 6.0039e-22
C_3_132 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:SiGeBXG285UTiSiXG296X1 1.4408e-23
C_3_133 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:SiGeBXG286UTiSiXG296X1 2.2918e-25
C_3_134 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:SiGeBXG323UTiSiXG296X1 2.2300e-25
C_3_135 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:SiGeBXG327UTiSiXG296X1 2.2238e-25
C_3_136 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:SiliconNXG302UTiSiXG295X1 1.5282e-21
C_3_137 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:n1d 2.7178e-21
C_3_138 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:n2s 2.7178e-21
C_3_139 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:n4g 3.2907e-22
C_3_140 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:p1d 5.4903e-22
C_3_141 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ1:p2g 2.0389e-22
C_3_142 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.8988e-18
C_3_143 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 3.8486e-22
C_3_144 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 3.7476e-22
C_3_145 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 3.7476e-22
C_3_146 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:SDexcludeXG265UTiSiXG299X1 3.5293e-22
C_3_147 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.5818e-22
C_3_148 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.4360e-22
C_3_149 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:SiGeBXG288UTiSiXG299X1 1.0150e-23
C_3_150 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:SiGeBXG290UTiSiXG299X1 2.8269e-26
C_3_151 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:SiGeBXG328UTiSiXG299X1 2.4578e-26
C_3_152 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:SiliconNXG305UTiSiXG300X1 8.3272e-24
C_3_153 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:n1g 2.2392e-19
C_3_154 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:n3d 3.1003e-22
C_3_155 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:n4s 3.1003e-22
C_3_156 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:p1g 2.9973e-21
C_3_157 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 iQ2:p2s 3.6303e-22
C_3_158 VSS:LM00Cobalt2XG21UTiSiXG30X1 WLL 5.4692e-22
C_3_159 VSS:LM00Cobalt2XG21UTiSiXG30X1 WLR 5.4692e-22
C_3_160 VSS:LM00Cobalt2XG21UTiSiXG30X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 1.5897e-21
C_3_161 VSS:LM00Cobalt2XG21UTiSiXG30X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 1.3587e-21
C_3_162 VSS:LM00Cobalt2XG21UTiSiXG30X1 BLB:SiliconNXG72UTiSiXG73X1 8.5250e-22
C_3_163 VSS:LM00Cobalt2XG21UTiSiXG30X1 BLB:n3s 2.2507e-21
C_3_164 VSS:LM00Cobalt2XG21UTiSiXG30X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 3.6672e-19
C_3_165 VSS:LM00Cobalt2XG21UTiSiXG30X1 BL:LM00Cobalt2XG535UTiSiXG524X1 8.8062e-23
C_3_166 VSS:LM00Cobalt2XG21UTiSiXG30X1 BL:SiliconNXG516UTiSiXG524X1 2.3696e-22
C_3_167 VSS:LM00Cobalt2XG21UTiSiXG30X1 BL:n2d 1.9349e-21
C_3_168 VSS:LM00Cobalt2XG21UTiSiXG30X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.1074e-21
C_3_169 VSS:LM00Cobalt2XG21UTiSiXG30X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.8318e-23
C_3_170 VSS:LM00Cobalt2XG21UTiSiXG30X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 5.4233e-21
C_3_171 VSS:LM00Cobalt2XG21UTiSiXG30X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 2.1138e-20
C_3_172 VSS:LM00Cobalt2XG21UTiSiXG30X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 5.5074e-22
C_3_173 VSS:LM00Cobalt2XG21UTiSiXG30X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.9204e-20
C_3_174 VSS:LM00Cobalt2XG21UTiSiXG30X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 5.4820e-22
C_3_175 VSS:LM00Cobalt2XG21UTiSiXG30X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.3684e-23
C_3_176 VSS:LM00Cobalt2XG21UTiSiXG30X1 WL:n2g 8.6944e-22
C_3_177 VSS:LM00Cobalt2XG21UTiSiXG30X1 WL:n3g 4.5005e-22
C_3_178 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 6.9072e-20
C_3_179 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 6.6913e-20
C_3_180 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 6.6993e-20
C_3_181 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 6.6899e-20
C_3_182 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:SDexcludeXG264UTiSiXG296X1 5.7217e-22
C_3_183 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:SDexcludeXG271UTiSiXG295X1 9.2431e-22
C_3_184 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:SDexcludeXG272UTiSiXG295X1 6.2549e-22
C_3_185 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:SiGeBXG285UTiSiXG296X1 1.5234e-23
C_3_186 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:SiGeBXG286UTiSiXG296X1 2.2887e-25
C_3_187 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:SiGeBXG323UTiSiXG296X1 2.2307e-25
C_3_188 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:SiGeBXG327UTiSiXG296X1 2.2240e-25
C_3_189 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:SiliconNXG302UTiSiXG295X1 1.4803e-21
C_3_190 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:n1d 2.7448e-21
C_3_191 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:n2s 2.7448e-21
C_3_192 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:n4g 3.5105e-22
C_3_193 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:p1d 5.8696e-22
C_3_194 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ1:p2g 2.1755e-22
C_3_195 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.8644e-18
C_3_196 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 3.8648e-22
C_3_197 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 3.7580e-22
C_3_198 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 3.7581e-22
C_3_199 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:SDexcludeXG265UTiSiXG299X1 3.7671e-22
C_3_200 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.6872e-22
C_3_201 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.5317e-22
C_3_202 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:SiGeBXG288UTiSiXG299X1 1.0728e-23
C_3_203 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:SiGeBXG290UTiSiXG299X1 2.8082e-26
C_3_204 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:SiGeBXG328UTiSiXG299X1 2.4648e-26
C_3_205 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:SiliconNXG305UTiSiXG300X1 8.8701e-24
C_3_206 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:n1g 2.3203e-19
C_3_207 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:n3d 3.3068e-22
C_3_208 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:n4s 3.3068e-22
C_3_209 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:p1g 3.1199e-21
C_3_210 VSS:LM00Cobalt2XG21UTiSiXG30X1 iQ2:p2s 3.8739e-22
C_3_211 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 WLL 3.7903e-20
C_3_212 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 WLR 3.7903e-20
C_3_213 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 9.2337e-19
C_3_214 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 1.7383e-22
C_3_215 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 BLB:SiliconNXG72UTiSiXG73X1 2.2541e-22
C_3_216 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 BLB:n3s 1.8299e-21
C_3_217 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 1.6544e-21
C_3_218 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 BL:LM00Cobalt2XG535UTiSiXG524X1 1.4131e-21
C_3_219 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 BL:SiliconNXG516UTiSiXG524X1 8.0126e-22
C_3_220 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 BL:n2d 2.1155e-21
C_3_221 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.1421e-20
C_3_222 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 5.3617e-19
C_3_223 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.0362e-21
C_3_224 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 1.4168e-23
C_3_225 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 3.7906e-20
C_3_226 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.0647e-23
C_3_227 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 5.2910e-20
C_3_228 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 5.4461e-19
C_3_229 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 WL:n2g 4.2161e-22
C_3_230 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 WL:n3g 8.3753e-22
C_3_231 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 2.9170e-18
C_3_232 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 3.8131e-22
C_3_233 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 3.7123e-22
C_3_234 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 3.7123e-22
C_3_235 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:SDexcludeXG264UTiSiXG296X1 3.5355e-22
C_3_236 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:SDexcludeXG271UTiSiXG295X1 1.4338e-22
C_3_237 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:SDexcludeXG272UTiSiXG295X1 1.5845e-22
C_3_238 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:SiGeBXG285UTiSiXG296X1 1.0113e-23
C_3_239 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:SiGeBXG286UTiSiXG296X1 2.4067e-26
C_3_240 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:SiGeBXG323UTiSiXG296X1 2.0032e-26
C_3_241 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:SiGeBXG327UTiSiXG296X1 1.9421e-26
C_3_242 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:SiliconNXG302UTiSiXG295X1 8.2747e-24
C_3_243 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:n1d 3.1006e-22
C_3_244 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:n2s 3.1006e-22
C_3_245 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:n4g 2.2525e-19
C_3_246 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:p1d 3.6363e-22
C_3_247 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ1:p2g 2.9885e-21
C_3_248 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 9.5727e-20
C_3_249 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 9.3693e-20
C_3_250 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 9.3679e-20
C_3_251 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 9.3983e-20
C_3_252 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:SDexcludeXG265UTiSiXG299X1 5.3520e-22
C_3_253 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:SDexcludeXG273UTiSiXG300X1 8.0199e-22
C_3_254 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.1106e-21
C_3_255 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:SiGeBXG288UTiSiXG299X1 1.4497e-23
C_3_256 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:SiGeBXG290UTiSiXG299X1 2.4599e-25
C_3_257 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:SiGeBXG328UTiSiXG299X1 2.4880e-25
C_3_258 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:SiliconNXG305UTiSiXG300X1 2.0342e-21
C_3_259 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:n1g 3.2872e-22
C_3_260 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:n3d 3.0330e-21
C_3_261 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:n4s 3.0330e-21
C_3_262 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:p1g 2.0425e-22
C_3_263 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 iQ2:p2s 5.4921e-22
C_3_264 VSS:LM00Cobalt2XG539UTiSiXG530X1 WLL 5.5950e-22
C_3_265 VSS:LM00Cobalt2XG539UTiSiXG530X1 WLR 5.5950e-22
C_3_266 VSS:LM00Cobalt2XG539UTiSiXG530X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 3.6426e-19
C_3_267 VSS:LM00Cobalt2XG539UTiSiXG530X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 8.8375e-23
C_3_268 VSS:LM00Cobalt2XG539UTiSiXG530X1 BLB:SiliconNXG72UTiSiXG73X1 2.3911e-22
C_3_269 VSS:LM00Cobalt2XG539UTiSiXG530X1 BLB:n3s 1.9479e-21
C_3_270 VSS:LM00Cobalt2XG539UTiSiXG530X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 1.6616e-21
C_3_271 VSS:LM00Cobalt2XG539UTiSiXG530X1 BL:LM00Cobalt2XG535UTiSiXG524X1 1.4304e-21
C_3_272 VSS:LM00Cobalt2XG539UTiSiXG530X1 BL:SiliconNXG516UTiSiXG524X1 8.3534e-22
C_3_273 VSS:LM00Cobalt2XG539UTiSiXG530X1 BL:n2d 2.2338e-21
C_3_274 VSS:LM00Cobalt2XG539UTiSiXG530X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 6.6677e-21
C_3_275 VSS:LM00Cobalt2XG539UTiSiXG530X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.4034e-20
C_3_276 VSS:LM00Cobalt2XG539UTiSiXG530X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.0925e-21
C_3_277 VSS:LM00Cobalt2XG539UTiSiXG530X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 1.4160e-23
C_3_278 VSS:LM00Cobalt2XG539UTiSiXG530X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 5.6209e-22
C_3_279 VSS:LM00Cobalt2XG539UTiSiXG530X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.0429e-23
C_3_280 VSS:LM00Cobalt2XG539UTiSiXG530X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 5.6327e-22
C_3_281 VSS:LM00Cobalt2XG539UTiSiXG530X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.1429e-20
C_3_282 VSS:LM00Cobalt2XG539UTiSiXG530X1 WL:n2g 4.4902e-22
C_3_283 VSS:LM00Cobalt2XG539UTiSiXG530X1 WL:n3g 8.8092e-22
C_3_284 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 2.8692e-18
C_3_285 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 3.8282e-22
C_3_286 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 3.7216e-22
C_3_287 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 3.7216e-22
C_3_288 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:SDexcludeXG264UTiSiXG296X1 3.7758e-22
C_3_289 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:SDexcludeXG271UTiSiXG295X1 1.5301e-22
C_3_290 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:SDexcludeXG272UTiSiXG295X1 1.6909e-22
C_3_291 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:SiGeBXG285UTiSiXG296X1 1.0696e-23
C_3_292 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:SiGeBXG286UTiSiXG296X1 2.3914e-26
C_3_293 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:SiGeBXG323UTiSiXG296X1 2.0148e-26
C_3_294 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:SiGeBXG327UTiSiXG296X1 1.9493e-26
C_3_295 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:SiliconNXG302UTiSiXG295X1 8.8196e-24
C_3_296 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:n1d 3.3086e-22
C_3_297 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:n2s 3.3086e-22
C_3_298 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:n4g 2.3357e-19
C_3_299 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:p1d 3.8823e-22
C_3_300 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ1:p2g 3.1119e-21
C_3_301 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 6.7114e-20
C_3_302 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 6.4948e-20
C_3_303 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 6.4933e-20
C_3_304 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 6.5206e-20
C_3_305 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:SDexcludeXG265UTiSiXG299X1 5.7259e-22
C_3_306 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:SDexcludeXG273UTiSiXG300X1 8.0293e-22
C_3_307 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.1110e-21
C_3_308 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:SiGeBXG288UTiSiXG299X1 1.5335e-23
C_3_309 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:SiGeBXG290UTiSiXG299X1 2.4437e-25
C_3_310 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:SiGeBXG328UTiSiXG299X1 2.4748e-25
C_3_311 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:SiliconNXG305UTiSiXG300X1 1.9093e-21
C_3_312 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:n1g 3.5083e-22
C_3_313 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:n3d 3.0042e-21
C_3_314 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:n4s 3.0042e-21
C_3_315 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:p1g 2.1804e-22
C_3_316 VSS:LM00Cobalt2XG539UTiSiXG530X1 iQ2:p2s 5.8744e-22
C_3_317 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 WLL 3.0628e-19
C_3_318 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 WLR 3.0628e-19
C_3_319 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 4.1771e-23
C_3_320 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 1.4444e-23
C_3_321 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 BLB:SiliconNXG72UTiSiXG73X1 3.2116e-24
C_3_322 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 BLB:n3s 5.2194e-24
C_3_323 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 1.5206e-19
C_3_324 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 BL:LM00Cobalt2XG535UTiSiXG524X1 1.0083e-24
C_3_325 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 BL:SiliconNXG516UTiSiXG524X1 4.0951e-25
C_3_326 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 BL:n2d 2.5568e-24
C_3_327 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 2.9527e-24
C_3_328 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.8625e-24
C_3_329 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 2.5470e-24
C_3_330 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 2.1190e-20
C_3_331 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 3.1210e-19
C_3_332 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 2.7006e-20
C_3_333 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 3.0629e-19
C_3_334 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 7.7726e-24
C_3_335 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 WL:n2g 9.8235e-25
C_3_336 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 WL:n3g 5.9609e-25
C_3_337 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 1.7219e-23
C_3_338 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 1.4798e-23
C_3_339 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.4787e-23
C_3_340 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.4784e-23
C_3_341 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:SDexcludeXG264UTiSiXG296X1 6.7824e-25
C_3_342 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:SDexcludeXG271UTiSiXG295X1 7.6063e-25
C_3_343 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:SDexcludeXG272UTiSiXG295X1 6.0668e-25
C_3_344 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:SiGeBXG285UTiSiXG296X1 1.4493e-26
C_3_345 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:SiGeBXG286UTiSiXG296X1 1.8254e-28
C_3_346 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:SiGeBXG323UTiSiXG296X1 1.6136e-28
C_3_347 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:SiGeBXG327UTiSiXG296X1 1.6055e-28
C_3_348 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:SiliconNXG302UTiSiXG295X1 1.0392e-25
C_3_349 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:n1d 1.4610e-24
C_3_350 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:n2s 1.4610e-24
C_3_351 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:n4g 3.3173e-25
C_3_352 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:p1d 6.9241e-25
C_3_353 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ1:p2g 2.4384e-25
C_3_354 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.5255e-22
C_3_355 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.8761e-24
C_3_356 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.8607e-24
C_3_357 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.8607e-24
C_3_358 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:SDexcludeXG265UTiSiXG299X1 4.7061e-25
C_3_359 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.8501e-25
C_3_360 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.6034e-25
C_3_361 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:SiGeBXG288UTiSiXG299X1 1.5542e-26
C_3_362 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:SiGeBXG290UTiSiXG299X1 6.9964e-29
C_3_363 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:SiGeBXG328UTiSiXG299X1 4.0114e-29
C_3_364 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:SiliconNXG305UTiSiXG300X1 1.0918e-26
C_3_365 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:n1g 7.7584e-24
C_3_366 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:n3d 3.5601e-25
C_3_367 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:n4s 3.5601e-25
C_3_368 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:p1g 1.8601e-24
C_3_369 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 iQ2:p2s 4.8608e-25
C_3_370 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 WLL 7.3256e-20
C_3_371 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 WLR 7.3256e-20
C_3_372 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 5.5863e-23
C_3_373 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 3.6193e-23
C_3_374 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 BLB:SiliconNXG72UTiSiXG73X1 1.3332e-23
C_3_375 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 BLB:n3s 3.1773e-23
C_3_376 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 5.7555e-19
C_3_377 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 BL:LM00Cobalt2XG535UTiSiXG524X1 4.4274e-23
C_3_378 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 BL:SiliconNXG516UTiSiXG524X1 3.7795e-24
C_3_379 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 BL:n2d 2.7464e-23
C_3_380 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.6429e-23
C_3_381 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 8.7340e-25
C_3_382 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 2.1785e-21
C_3_383 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 5.3851e-19
C_3_384 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 8.4956e-20
C_3_385 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 5.4846e-19
C_3_386 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 7.3256e-20
C_3_387 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 8.8512e-25
C_3_388 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 WL:n2g 1.4082e-23
C_3_389 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 WL:n3g 6.0553e-24
C_3_390 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 1.9893e-20
C_3_391 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 1.9863e-20
C_3_392 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.9870e-20
C_3_393 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.9863e-20
C_3_394 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:SDexcludeXG264UTiSiXG296X1 7.5499e-24
C_3_395 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:SDexcludeXG271UTiSiXG295X1 2.2318e-23
C_3_396 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:SDexcludeXG272UTiSiXG295X1 1.5111e-23
C_3_397 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:SiGeBXG285UTiSiXG296X1 1.8813e-25
C_3_398 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:SiGeBXG286UTiSiXG296X1 6.7888e-28
C_3_399 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:SiGeBXG323UTiSiXG296X1 3.0681e-28
C_3_400 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:SiGeBXG327UTiSiXG296X1 2.9713e-28
C_3_401 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:SiliconNXG302UTiSiXG295X1 5.6779e-23
C_3_402 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:n1d 7.1534e-23
C_3_403 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:n2s 7.1534e-23
C_3_404 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:n4g 4.7543e-24
C_3_405 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:p1d 7.7375e-24
C_3_406 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ1:p2g 2.9334e-24
C_3_407 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 5.4952e-20
C_3_408 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 8.3234e-24
C_3_409 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 8.1903e-24
C_3_410 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 8.1906e-24
C_3_411 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:SDexcludeXG265UTiSiXG299X1 4.9962e-24
C_3_412 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:SDexcludeXG273UTiSiXG300X1 2.2763e-24
C_3_413 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:SDexcludeXG274UTiSiXG300X1 2.0783e-24
C_3_414 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:SiGeBXG288UTiSiXG299X1 1.3340e-25
C_3_415 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:SiGeBXG290UTiSiXG299X1 4.8461e-28
C_3_416 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:SiGeBXG328UTiSiXG299X1 1.6294e-28
C_3_417 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:SiliconNXG305UTiSiXG300X1 1.2062e-25
C_3_418 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:n1g 2.7867e-22
C_3_419 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:n3d 4.4738e-24
C_3_420 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:n4s 4.4738e-24
C_3_421 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:p1g 1.6501e-23
C_3_422 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 iQ2:p2s 5.1293e-24
C_3_423 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 WLL 3.1799e-19
C_3_424 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 WLR 3.1799e-19
C_3_425 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 1.4782e-19
C_3_426 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 1.0724e-24
C_3_427 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 BLB:SiliconNXG72UTiSiXG73X1 3.9117e-25
C_3_428 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 BLB:n3s 2.3409e-24
C_3_429 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 3.8927e-23
C_3_430 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 BL:LM00Cobalt2XG535UTiSiXG524X1 1.4532e-23
C_3_431 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 BL:SiliconNXG516UTiSiXG524X1 3.0823e-24
C_3_432 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 BL:n2d 5.1534e-24
C_3_433 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 2.4833e-24
C_3_434 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 1.0625e-20
C_3_435 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 2.8723e-24
C_3_436 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 8.3653e-25
C_3_437 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 3.1800e-19
C_3_438 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 5.9896e-24
C_3_439 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 3.2358e-19
C_3_440 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.6216e-20
C_3_441 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 WL:n2g 6.2838e-25
C_3_442 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 WL:n3g 8.9642e-25
C_3_443 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 1.5312e-22
C_3_444 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 2.7862e-24
C_3_445 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 2.7716e-24
C_3_446 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 2.7715e-24
C_3_447 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:SDexcludeXG264UTiSiXG296X1 4.4406e-25
C_3_448 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:SDexcludeXG271UTiSiXG295X1 1.7999e-25
C_3_449 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:SDexcludeXG272UTiSiXG295X1 1.9942e-25
C_3_450 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:SiGeBXG285UTiSiXG296X1 1.4796e-26
C_3_451 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:SiGeBXG286UTiSiXG296X1 6.5045e-29
C_3_452 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:SiGeBXG323UTiSiXG296X1 3.8808e-29
C_3_453 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:SiGeBXG327UTiSiXG296X1 3.8015e-29
C_3_454 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:SiliconNXG302UTiSiXG295X1 1.1591e-26
C_3_455 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:n1d 3.9073e-25
C_3_456 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:n2s 3.9073e-25
C_3_457 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:n4g 7.6050e-24
C_3_458 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:p1d 4.5878e-25
C_3_459 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ1:p2g 1.6921e-24
C_3_460 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.7257e-23
C_3_461 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 1.4700e-23
C_3_462 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 1.4685e-23
C_3_463 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 1.4693e-23
C_3_464 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:SDexcludeXG265UTiSiXG299X1 6.3329e-25
C_3_465 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:SDexcludeXG273UTiSiXG300X1 5.6982e-25
C_3_466 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:SDexcludeXG274UTiSiXG300X1 7.3377e-25
C_3_467 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:SiGeBXG288UTiSiXG299X1 1.5435e-26
C_3_468 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:SiGeBXG290UTiSiXG299X1 1.8026e-28
C_3_469 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:SiGeBXG328UTiSiXG299X1 1.4072e-28
C_3_470 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:SiliconNXG305UTiSiXG300X1 1.0391e-25
C_3_471 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:n1g 4.0480e-25
C_3_472 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:n3d 1.3818e-24
C_3_473 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:n4s 1.3818e-24
C_3_474 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:p1g 3.4189e-25
C_3_475 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 iQ2:p2s 6.4845e-25
C_3_476 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 WLL 8.6990e-20
C_3_477 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 WLR 8.6990e-20
C_3_478 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 6.3688e-19
C_3_479 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 8.7417e-23
C_3_480 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 BLB:SiliconNXG72UTiSiXG73X1 4.3363e-24
C_3_481 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 BLB:n3s 2.8589e-23
C_3_482 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 5.7716e-23
C_3_483 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 BL:LM00Cobalt2XG535UTiSiXG524X1 3.8252e-23
C_3_484 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 BL:SiliconNXG516UTiSiXG524X1 1.3201e-23
C_3_485 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 BL:n2d 3.1830e-23
C_3_486 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 4.8595e-21
C_3_487 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 5.3032e-19
C_3_488 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.6317e-23
C_3_489 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 6.1097e-25
C_3_490 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 8.6990e-20
C_3_491 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 6.7882e-25
C_3_492 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 1.0608e-19
C_3_493 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 5.4544e-19
C_3_494 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 WL:n2g 6.0544e-24
C_3_495 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 WL:n3g 1.7849e-23
C_3_496 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 6.8808e-20
C_3_497 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 8.3427e-24
C_3_498 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 8.2107e-24
C_3_499 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 8.2106e-24
C_3_500 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:SDexcludeXG264UTiSiXG296X1 5.0063e-24
C_3_501 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:SDexcludeXG271UTiSiXG295X1 2.0767e-24
C_3_502 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:SDexcludeXG272UTiSiXG295X1 2.2803e-24
C_3_503 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:SiGeBXG285UTiSiXG296X1 1.3241e-25
C_3_504 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:SiGeBXG286UTiSiXG296X1 4.8890e-28
C_3_505 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:SiGeBXG323UTiSiXG296X1 1.8117e-28
C_3_506 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:SiGeBXG327UTiSiXG296X1 1.7157e-28
C_3_507 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:SiliconNXG302UTiSiXG295X1 1.1874e-25
C_3_508 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:n1d 4.4751e-24
C_3_509 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:n2s 4.4751e-24
C_3_510 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:n4g 3.3233e-22
C_3_511 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:p1d 5.1384e-24
C_3_512 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ1:p2g 1.6580e-23
C_3_513 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.8804e-20
C_3_514 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.8773e-20
C_3_515 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.8773e-20
C_3_516 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.8805e-20
C_3_517 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:SDexcludeXG265UTiSiXG299X1 7.6030e-24
C_3_518 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:SDexcludeXG273UTiSiXG300X1 3.9909e-23
C_3_519 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:SDexcludeXG274UTiSiXG300X1 5.0207e-23
C_3_520 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:SiGeBXG288UTiSiXG299X1 1.8869e-25
C_3_521 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:SiGeBXG290UTiSiXG299X1 1.9752e-27
C_3_522 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:SiGeBXG328UTiSiXG299X1 1.6082e-27
C_3_523 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:SiliconNXG305UTiSiXG300X1 1.3495e-22
C_3_524 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:n1g 4.7726e-24
C_3_525 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:n3d 1.2832e-22
C_3_526 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:n4s 1.2832e-22
C_3_527 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:p1g 2.9808e-24
C_3_528 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 iQ2:p2s 7.7885e-24
C_3_529 VSS:SiliconNXG29UTiSiXG30X1 WLL 3.9090e-23
C_3_530 VSS:SiliconNXG29UTiSiXG30X1 WLR 3.9090e-23
C_3_531 VSS:SiliconNXG29UTiSiXG30X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 1.2987e-21
C_3_532 VSS:SiliconNXG29UTiSiXG30X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 1.2301e-21
C_3_533 VSS:SiliconNXG29UTiSiXG30X1 BLB:SiliconNXG72UTiSiXG73X1 2.6643e-21
C_3_534 VSS:SiliconNXG29UTiSiXG30X1 BLB:n3s 1.2967e-20
C_3_535 VSS:SiliconNXG29UTiSiXG30X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 9.8553e-21
C_3_536 VSS:SiliconNXG29UTiSiXG30X1 BL:LM00Cobalt2XG535UTiSiXG524X1 2.2838e-22
C_3_537 VSS:SiliconNXG29UTiSiXG30X1 BL:SiliconNXG516UTiSiXG524X1 2.1958e-21
C_3_538 VSS:SiliconNXG29UTiSiXG30X1 BL:n2d 1.8029e-20
C_3_539 VSS:SiliconNXG29UTiSiXG30X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 6.3458e-21
C_3_540 VSS:SiliconNXG29UTiSiXG30X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 2.1642e-23
C_3_541 VSS:SiliconNXG29UTiSiXG30X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.3710e-20
C_3_542 VSS:SiliconNXG29UTiSiXG30X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 9.5352e-23
C_3_543 VSS:SiliconNXG29UTiSiXG30X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 3.9701e-23
C_3_544 VSS:SiliconNXG29UTiSiXG30X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 5.9239e-23
C_3_545 VSS:SiliconNXG29UTiSiXG30X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 3.9632e-23
C_3_546 VSS:SiliconNXG29UTiSiXG30X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.0962e-23
C_3_547 VSS:SiliconNXG29UTiSiXG30X1 WL:n2g 6.0193e-23
C_3_548 VSS:SiliconNXG29UTiSiXG30X1 WL:n3g 3.2988e-23
C_3_549 VSS:SiliconNXG29UTiSiXG30X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 1.5889e-20
C_3_550 VSS:SiliconNXG29UTiSiXG30X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 9.0751e-22
C_3_551 VSS:SiliconNXG29UTiSiXG30X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 8.0836e-22
C_3_552 VSS:SiliconNXG29UTiSiXG30X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 7.8419e-22
C_3_553 VSS:SiliconNXG29UTiSiXG30X1 iQ1:SDexcludeXG264UTiSiXG296X1 5.3321e-21
C_3_554 VSS:SiliconNXG29UTiSiXG30X1 iQ1:SDexcludeXG271UTiSiXG295X1 6.8270e-21
C_3_555 VSS:SiliconNXG29UTiSiXG30X1 iQ1:SDexcludeXG272UTiSiXG295X1 5.3702e-21
C_3_556 VSS:SiliconNXG29UTiSiXG30X1 iQ1:SiGeBXG285UTiSiXG296X1 1.2334e-22
C_3_557 VSS:SiliconNXG29UTiSiXG30X1 iQ1:SiGeBXG286UTiSiXG296X1 1.1721e-26
C_3_558 VSS:SiliconNXG29UTiSiXG30X1 iQ1:SiGeBXG323UTiSiXG296X1 1.5318e-26
C_3_559 VSS:SiliconNXG29UTiSiXG30X1 iQ1:SiGeBXG327UTiSiXG296X1 9.4054e-27
C_3_560 VSS:SiliconNXG29UTiSiXG30X1 iQ1:SiliconNXG302UTiSiXG295X1 1.4434e-21
C_3_561 VSS:SiliconNXG29UTiSiXG30X1 iQ1:n1d 1.3568e-20
C_3_562 VSS:SiliconNXG29UTiSiXG30X1 iQ1:n2s 1.3568e-20
C_3_563 VSS:SiliconNXG29UTiSiXG30X1 iQ1:n4g 2.6523e-23
C_3_564 VSS:SiliconNXG29UTiSiXG30X1 iQ1:p1d 5.4554e-21
C_3_565 VSS:SiliconNXG29UTiSiXG30X1 iQ1:p2g 1.6472e-23
C_3_566 VSS:SiliconNXG29UTiSiXG30X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.0877e-18
C_3_567 VSS:SiliconNXG29UTiSiXG30X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.3439e-22
C_3_568 VSS:SiliconNXG29UTiSiXG30X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 1.5749e-22
C_3_569 VSS:SiliconNXG29UTiSiXG30X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 1.5759e-22
C_3_570 VSS:SiliconNXG29UTiSiXG30X1 iQ2:SDexcludeXG265UTiSiXG299X1 3.2288e-21
C_3_571 VSS:SiliconNXG29UTiSiXG30X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.4673e-21
C_3_572 VSS:SiliconNXG29UTiSiXG30X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.3514e-21
C_3_573 VSS:SiliconNXG29UTiSiXG30X1 iQ2:SiGeBXG288UTiSiXG299X1 7.6913e-23
C_3_574 VSS:SiliconNXG29UTiSiXG30X1 iQ2:SiGeBXG290UTiSiXG299X1 9.7906e-27
C_3_575 VSS:SiliconNXG29UTiSiXG30X1 iQ2:SiGeBXG328UTiSiXG299X1 7.6832e-27
C_3_576 VSS:SiliconNXG29UTiSiXG30X1 iQ2:SiliconNXG305UTiSiXG300X1 7.4071e-23
C_3_577 VSS:SiliconNXG29UTiSiXG30X1 iQ2:n1g 8.3843e-21
C_3_578 VSS:SiliconNXG29UTiSiXG30X1 iQ2:n3d 2.8925e-21
C_3_579 VSS:SiliconNXG29UTiSiXG30X1 iQ2:n4s 2.8925e-21
C_3_580 VSS:SiliconNXG29UTiSiXG30X1 iQ2:p1g 1.3819e-22
C_3_581 VSS:SiliconNXG29UTiSiXG30X1 iQ2:p2s 3.3057e-21
C_3_582 VSS:SiliconNXG519UTiSiXG530X1 WLL 3.9706e-23
C_3_583 VSS:SiliconNXG519UTiSiXG530X1 WLR 3.9706e-23
C_3_584 VSS:SiliconNXG519UTiSiXG530X1 BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 9.7633e-21
C_3_585 VSS:SiliconNXG519UTiSiXG530X1 BLB:LM00Cobalt2XG71UTiSiXG73X1 2.2056e-22
C_3_586 VSS:SiliconNXG519UTiSiXG530X1 BLB:SiliconNXG72UTiSiXG73X1 2.2119e-21
C_3_587 VSS:SiliconNXG519UTiSiXG530X1 BLB:n3s 1.8118e-20
C_3_588 VSS:SiliconNXG519UTiSiXG530X1 BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 1.3696e-21
C_3_589 VSS:SiliconNXG519UTiSiXG530X1 BL:LM00Cobalt2XG535UTiSiXG524X1 1.3003e-21
C_3_590 VSS:SiliconNXG519UTiSiXG530X1 BL:SiliconNXG516UTiSiXG524X1 2.6403e-21
C_3_591 VSS:SiliconNXG519UTiSiXG530X1 BL:n2d 1.2935e-20
C_3_592 VSS:SiliconNXG519UTiSiXG530X1 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.3766e-20
C_3_593 VSS:SiliconNXG519UTiSiXG530X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 9.0599e-23
C_3_594 VSS:SiliconNXG519UTiSiXG530X1 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 6.3362e-21
C_3_595 VSS:SiliconNXG519UTiSiXG530X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 1.8458e-23
C_3_596 VSS:SiliconNXG519UTiSiXG530X1 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 4.1107e-23
C_3_597 VSS:SiliconNXG519UTiSiXG530X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 8.2374e-24
C_3_598 VSS:SiliconNXG519UTiSiXG530X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 3.9951e-23
C_3_599 VSS:SiliconNXG519UTiSiXG530X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 4.3000e-23
C_3_600 VSS:SiliconNXG519UTiSiXG530X1 WL:n2g 3.3159e-23
C_3_601 VSS:SiliconNXG519UTiSiXG530X1 WL:n3g 6.0775e-23
C_3_602 VSS:SiliconNXG519UTiSiXG530X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 2.0959e-18
C_3_603 VSS:SiliconNXG519UTiSiXG530X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 2.3164e-22
C_3_604 VSS:SiliconNXG519UTiSiXG530X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.5493e-22
C_3_605 VSS:SiliconNXG519UTiSiXG530X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.5491e-22
C_3_606 VSS:SiliconNXG519UTiSiXG530X1 iQ1:SDexcludeXG264UTiSiXG296X1 3.2328e-21
C_3_607 VSS:SiliconNXG519UTiSiXG530X1 iQ1:SDexcludeXG271UTiSiXG295X1 1.3481e-21
C_3_608 VSS:SiliconNXG519UTiSiXG530X1 iQ1:SDexcludeXG272UTiSiXG295X1 1.4686e-21
C_3_609 VSS:SiliconNXG519UTiSiXG530X1 iQ1:SiGeBXG285UTiSiXG296X1 7.6757e-23
C_3_610 VSS:SiliconNXG519UTiSiXG530X1 iQ1:SiGeBXG286UTiSiXG296X1 1.5340e-26
C_3_611 VSS:SiliconNXG519UTiSiXG530X1 iQ1:SiGeBXG323UTiSiXG296X1 1.6933e-26
C_3_612 VSS:SiliconNXG519UTiSiXG530X1 iQ1:SiGeBXG327UTiSiXG296X1 1.1154e-26
C_3_613 VSS:SiliconNXG519UTiSiXG530X1 iQ1:SiliconNXG302UTiSiXG295X1 7.3605e-23
C_3_614 VSS:SiliconNXG519UTiSiXG530X1 iQ1:n1d 2.8902e-21
C_3_615 VSS:SiliconNXG519UTiSiXG530X1 iQ1:n2s 2.8902e-21
C_3_616 VSS:SiliconNXG519UTiSiXG530X1 iQ1:n4g 8.6464e-21
C_3_617 VSS:SiliconNXG519UTiSiXG530X1 iQ1:p1d 3.3096e-21
C_3_618 VSS:SiliconNXG519UTiSiXG530X1 iQ1:p2g 1.3911e-22
C_3_619 VSS:SiliconNXG519UTiSiXG530X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.5755e-20
C_3_620 VSS:SiliconNXG519UTiSiXG530X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 7.3061e-22
C_3_621 VSS:SiliconNXG519UTiSiXG530X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 6.0692e-22
C_3_622 VSS:SiliconNXG519UTiSiXG530X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 6.8194e-22
C_3_623 VSS:SiliconNXG519UTiSiXG530X1 iQ2:SDexcludeXG265UTiSiXG299X1 5.3297e-21
C_3_624 VSS:SiliconNXG519UTiSiXG530X1 iQ2:SDexcludeXG273UTiSiXG300X1 5.4073e-21
C_3_625 VSS:SiliconNXG519UTiSiXG530X1 iQ2:SDexcludeXG274UTiSiXG300X1 6.8668e-21
C_3_626 VSS:SiliconNXG519UTiSiXG530X1 iQ2:SiGeBXG288UTiSiXG299X1 1.2370e-22
C_3_627 VSS:SiliconNXG519UTiSiXG530X1 iQ2:SiGeBXG290UTiSiXG299X1 8.9454e-27
C_3_628 VSS:SiliconNXG519UTiSiXG530X1 iQ2:SiGeBXG328UTiSiXG299X1 6.6819e-27
C_3_629 VSS:SiliconNXG519UTiSiXG530X1 iQ2:SiliconNXG305UTiSiXG300X1 1.5453e-21
C_3_630 VSS:SiliconNXG519UTiSiXG530X1 iQ2:n1g 2.6679e-23
C_3_631 VSS:SiliconNXG519UTiSiXG530X1 iQ2:n3d 1.3594e-20
C_3_632 VSS:SiliconNXG519UTiSiXG530X1 iQ2:n4s 1.3594e-20
C_3_633 VSS:SiliconNXG519UTiSiXG530X1 iQ2:p1g 1.6615e-23
C_3_634 VSS:SiliconNXG519UTiSiXG530X1 iQ2:p2s 5.4534e-21
C_3_635 VSS:n1s WLL 4.1821e-23
C_3_636 VSS:n1s WLR 4.1821e-23
C_3_637 VSS:n1s BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 3.2413e-21
C_3_638 VSS:n1s BLB:LM00Cobalt2XG71UTiSiXG73X1 3.1548e-21
C_3_639 VSS:n1s BLB:SiliconNXG72UTiSiXG73X1 1.4294e-20
C_3_640 VSS:n1s BLB:n3s 8.9582e-20
C_3_641 VSS:n1s BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 1.1644e-20
C_3_642 VSS:n1s BL:LM00Cobalt2XG535UTiSiXG524X1 1.9743e-21
C_3_643 VSS:n1s BL:SiliconNXG516UTiSiXG524X1 1.9297e-20
C_3_644 VSS:n1s BL:n2d 1.6239e-19
C_3_645 VSS:n1s WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 4.4467e-20
C_3_646 VSS:n1s WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 9.9244e-23
C_3_647 VSS:n1s WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 1.1984e-19
C_3_648 VSS:n1s WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 2.3281e-22
C_3_649 VSS:n1s WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 4.5865e-23
C_3_650 VSS:n1s WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.0893e-22
C_3_651 VSS:n1s WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 4.3034e-23
C_3_652 VSS:n1s WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 4.0022e-23
C_3_653 VSS:n1s iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 1.2580e-19
C_3_654 VSS:n1s iQ1:LM00Cobalt2XG308USiGeBXG285X1 2.2157e-21
C_3_655 VSS:n1s iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.1111e-21
C_3_656 VSS:n1s iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.0784e-21
C_3_657 VSS:n1s iQ1:SDexcludeXG264UTiSiXG296X1 4.4669e-20
C_3_658 VSS:n1s iQ1:SDexcludeXG271UTiSiXG295X1 1.0812e-19
C_3_659 VSS:n1s iQ1:SDexcludeXG272UTiSiXG295X1 9.8655e-20
C_3_660 VSS:n1s iQ1:SiGeBXG285UTiSiXG296X1 1.1374e-21
C_3_661 VSS:n1s iQ1:SiGeBXG286UTiSiXG296X1 8.6624e-26
C_3_662 VSS:n1s iQ1:SiGeBXG323UTiSiXG296X1 1.0739e-25
C_3_663 VSS:n1s iQ1:SiGeBXG327UTiSiXG296X1 6.1595e-26
C_3_664 VSS:n1s iQ1:SiliconNXG302UTiSiXG295X1 5.2217e-21
C_3_665 VSS:n1s iQ1:n1d 2.1190e-19
C_3_666 VSS:n1s iQ1:n2s 2.1190e-19
C_3_667 VSS:n1s iQ1:p1d 4.5807e-20
C_3_668 VSS:n1s iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 5.4507e-18
C_3_669 VSS:n1s iQ2:LM00Cobalt2XG153USiGeBXG288X1 8.6105e-22
C_3_670 VSS:n1s iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.7214e-22
C_3_671 VSS:n1s iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.7285e-22
C_3_672 VSS:n1s iQ2:SDexcludeXG265UTiSiXG299X1 2.4847e-20
C_3_673 VSS:n1s iQ2:SDexcludeXG273UTiSiXG300X1 1.1507e-20
C_3_674 VSS:n1s iQ2:SDexcludeXG274UTiSiXG300X1 1.0696e-20
C_3_675 VSS:n1s iQ2:SiGeBXG288UTiSiXG299X1 5.8897e-22
C_3_676 VSS:n1s iQ2:SiGeBXG290UTiSiXG299X1 5.1875e-26
C_3_677 VSS:n1s iQ2:SiGeBXG328UTiSiXG299X1 2.9921e-26
C_3_678 VSS:n1s iQ2:SiliconNXG305UTiSiXG300X1 5.7719e-22
C_3_679 VSS:n1s iQ2:n3d 2.2777e-20
C_3_680 VSS:n1s iQ2:n4s 2.2777e-20
C_3_681 VSS:n1s iQ2:p2s 2.5436e-20
C_3_682 VSS:n4d WLL 4.2388e-23
C_3_683 VSS:n4d WLR 4.2388e-23
C_3_684 VSS:n4d BLB:LM00Cobalt2XG71ULM40Cobalt5XG77X1 1.1488e-20
C_3_685 VSS:n4d BLB:LM00Cobalt2XG71UTiSiXG73X1 1.9081e-21
C_3_686 VSS:n4d BLB:SiliconNXG72UTiSiXG73X1 1.9443e-20
C_3_687 VSS:n4d BLB:n3s 1.6324e-19
C_3_688 VSS:n4d BL:LM00Cobalt2XG535ULM40Cobalt5XG46X1 3.4142e-21
C_3_689 VSS:n4d BL:LM00Cobalt2XG535UTiSiXG524X1 3.3243e-21
C_3_690 VSS:n4d BL:SiliconNXG516UTiSiXG524X1 1.4234e-20
C_3_691 VSS:n4d BL:n2d 8.9524e-20
C_3_692 VSS:n4d WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 1.2010e-19
C_3_693 VSS:n4d WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 2.3673e-22
C_3_694 VSS:n4d WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 4.4507e-20
C_3_695 VSS:n4d WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 8.8278e-23
C_3_696 VSS:n4d WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 4.6582e-23
C_3_697 VSS:n4d WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 3.0169e-23
C_3_698 VSS:n4d WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 4.3468e-23
C_3_699 VSS:n4d WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 9.7897e-23
C_3_700 VSS:n4d iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 5.4550e-18
C_3_701 VSS:n4d iQ1:LM00Cobalt2XG308USiGeBXG285X1 8.5635e-22
C_3_702 VSS:n4d iQ1:LM00Cobalt2XG308UTiSiXG295X1 2.6809e-22
C_3_703 VSS:n4d iQ1:LM00Cobalt2XG308UTiSiXG296X1 2.6798e-22
C_3_704 VSS:n4d iQ1:SDexcludeXG264UTiSiXG296X1 2.4906e-20
C_3_705 VSS:n4d iQ1:SDexcludeXG271UTiSiXG295X1 1.0682e-20
C_3_706 VSS:n4d iQ1:SDexcludeXG272UTiSiXG295X1 1.1530e-20
C_3_707 VSS:n4d iQ1:SiGeBXG285UTiSiXG296X1 5.8850e-22
C_3_708 VSS:n4d iQ1:SiGeBXG286UTiSiXG296X1 9.5766e-26
C_3_709 VSS:n4d iQ1:SiGeBXG323UTiSiXG296X1 1.0882e-25
C_3_710 VSS:n4d iQ1:SiGeBXG327UTiSiXG296X1 6.4128e-26
C_3_711 VSS:n4d iQ1:SiliconNXG302UTiSiXG295X1 5.7430e-22
C_3_712 VSS:n4d iQ1:n1d 2.2786e-20
C_3_713 VSS:n4d iQ1:n2s 2.2786e-20
C_3_714 VSS:n4d iQ1:p1d 2.5494e-20
C_3_715 VSS:n4d iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.2606e-19
C_3_716 VSS:n4d iQ2:LM00Cobalt2XG153USiGeBXG288X1 1.9963e-21
C_3_717 VSS:n4d iQ2:LM00Cobalt2XG153UTiSiXG299X1 8.5477e-22
C_3_718 VSS:n4d iQ2:LM00Cobalt2XG153UTiSiXG300X1 9.5394e-22
C_3_719 VSS:n4d iQ2:SDexcludeXG265UTiSiXG299X1 4.4680e-20
C_3_720 VSS:n4d iQ2:SDexcludeXG273UTiSiXG300X1 9.8564e-20
C_3_721 VSS:n4d iQ2:SDexcludeXG274UTiSiXG300X1 1.0749e-19
C_3_722 VSS:n4d iQ2:SiGeBXG288UTiSiXG299X1 1.1416e-21
C_3_723 VSS:n4d iQ2:SiGeBXG290UTiSiXG299X1 5.6582e-26
C_3_724 VSS:n4d iQ2:SiGeBXG328UTiSiXG299X1 4.1317e-26
C_3_725 VSS:n4d iQ2:SiliconNXG305UTiSiXG300X1 5.3569e-21
C_3_726 VSS:n4d iQ2:n3d 2.1112e-19
C_3_727 VSS:n4d iQ2:n4s 2.1112e-19
C_3_728 VSS:n4d iQ2:p2s 4.5822e-20
R_3_0 VSS VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 4.3725e+01
R_3_1 VSS VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 4.3962e+01
R_3_2 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 VSS:LM00Cobalt2XG21UTiSiXG30X1 9.9691e+01
R_3_3 VSS:LM00Cobalt2XG21ULM40Cobalt5XG25X1 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 9.8435e+01
R_3_4 VSS:LM00Cobalt2XG21UTiSiXG30X1 VSS:SiliconNXG29UTiSiXG30X1 1.3564e+02
R_3_5 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 VSS:LM00Cobalt2XG539UTiSiXG530X1 9.9711e+01
R_3_6 VSS:LM00Cobalt2XG539ULM40Cobalt5XG370X1 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 9.6927e+01
R_3_7 VSS:LM00Cobalt2XG539UTiSiXG530X1 VSS:SiliconNXG519UTiSiXG530X1 1.3471e+02
R_3_8 VSS:LM20Cobalt3XG28ULM30Cobalt4XG13X1 VSS:LM20Cobalt3XG28ULM40Cobalt5XG25X1 3.5224e+01
R_3_9 VSS:LM20Cobalt3XG507ULM30Cobalt4XG509X1 VSS:LM20Cobalt3XG507ULM40Cobalt5XG370X1 3.5232e+01
R_3_10 VSS:SiliconNXG29UTiSiXG30X1 VSS:n1s 1.8699e+01
R_3_11 VSS:SiliconNXG519UTiSiXG530X1 VSS:n4d 2.0853e+01

*|NET WL 1.2571e-04PF
C_4_0 WLL iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 3.2723e-22
C_4_1 WLL iQ1:LM00Cobalt2XG308USiGeBXG285X1 7.4898e-23
C_4_2 WLL iQ1:LM00Cobalt2XG308UTiSiXG295X1 7.4836e-23
C_4_3 WLL iQ1:LM00Cobalt2XG308UTiSiXG296X1 7.4835e-23
C_4_4 WLL iQ1:SDexcludeXG264UTiSiXG296X1 9.2184e-25
C_4_5 WLL iQ1:SDexcludeXG271UTiSiXG295X1 4.4367e-25
C_4_6 WLL iQ1:SDexcludeXG272UTiSiXG295X1 4.6003e-25
C_4_7 WLL iQ1:SiGeBXG285UTiSiXG296X1 6.4211e-26
C_4_8 WLL iQ1:SiGeBXG286UTiSiXG296X1 8.0539e-28
C_4_9 WLL iQ1:SiGeBXG323UTiSiXG296X1 7.7831e-28
C_4_10 WLL iQ1:SiGeBXG327UTiSiXG296X1 7.7713e-28
C_4_11 WLL iQ1:SiliconNXG302UTiSiXG295X1 4.7465e-26
C_4_12 WLL iQ1:n1d 9.4413e-25
C_4_13 WLL iQ1:n2s 9.4413e-25
C_4_14 WLL iQ1:n4g 1.5188e-24
C_4_15 WLL iQ1:p1d 9.8450e-25
C_4_16 WLL iQ1:p2g 1.6109e-24
C_4_17 WLL iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 3.3011e-22
C_4_18 WLL iQ2:LM00Cobalt2XG153USiGeBXG288X1 7.5253e-23
C_4_19 WLL iQ2:LM00Cobalt2XG153UTiSiXG299X1 7.5188e-23
C_4_20 WLL iQ2:LM00Cobalt2XG153UTiSiXG300X1 7.5191e-23
C_4_21 WLL iQ2:SDexcludeXG265UTiSiXG299X1 9.0094e-25
C_4_22 WLL iQ2:SDexcludeXG273UTiSiXG300X1 4.6560e-25
C_4_23 WLL iQ2:SDexcludeXG274UTiSiXG300X1 4.3689e-25
C_4_24 WLL iQ2:SiGeBXG288UTiSiXG299X1 6.6697e-26
C_4_25 WLL iQ2:SiGeBXG290UTiSiXG299X1 9.1026e-28
C_4_26 WLL iQ2:SiGeBXG328UTiSiXG299X1 9.0635e-28
C_4_27 WLL iQ2:SiliconNXG305UTiSiXG300X1 4.7324e-26
C_4_28 WLL iQ2:n1g 1.4476e-24
C_4_29 WLL iQ2:n3d 9.3994e-25
C_4_30 WLL iQ2:n4s 9.3994e-25
C_4_31 WLL iQ2:p1g 1.6753e-24
C_4_32 WLL iQ2:p2s 9.6584e-25
C_4_33 WLR iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 3.2723e-22
C_4_34 WLR iQ1:LM00Cobalt2XG308USiGeBXG285X1 7.4898e-23
C_4_35 WLR iQ1:LM00Cobalt2XG308UTiSiXG295X1 7.4836e-23
C_4_36 WLR iQ1:LM00Cobalt2XG308UTiSiXG296X1 7.4835e-23
C_4_37 WLR iQ1:SDexcludeXG264UTiSiXG296X1 9.2184e-25
C_4_38 WLR iQ1:SDexcludeXG271UTiSiXG295X1 4.4367e-25
C_4_39 WLR iQ1:SDexcludeXG272UTiSiXG295X1 4.6003e-25
C_4_40 WLR iQ1:SiGeBXG285UTiSiXG296X1 6.4211e-26
C_4_41 WLR iQ1:SiGeBXG286UTiSiXG296X1 8.0539e-28
C_4_42 WLR iQ1:SiGeBXG323UTiSiXG296X1 7.7831e-28
C_4_43 WLR iQ1:SiGeBXG327UTiSiXG296X1 7.7713e-28
C_4_44 WLR iQ1:SiliconNXG302UTiSiXG295X1 4.7465e-26
C_4_45 WLR iQ1:n1d 9.4413e-25
C_4_46 WLR iQ1:n2s 9.4413e-25
C_4_47 WLR iQ1:n4g 1.5188e-24
C_4_48 WLR iQ1:p1d 9.8450e-25
C_4_49 WLR iQ1:p2g 1.6109e-24
C_4_50 WLR iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 3.3011e-22
C_4_51 WLR iQ2:LM00Cobalt2XG153USiGeBXG288X1 7.5253e-23
C_4_52 WLR iQ2:LM00Cobalt2XG153UTiSiXG299X1 7.5188e-23
C_4_53 WLR iQ2:LM00Cobalt2XG153UTiSiXG300X1 7.5191e-23
C_4_54 WLR iQ2:SDexcludeXG265UTiSiXG299X1 9.0094e-25
C_4_55 WLR iQ2:SDexcludeXG273UTiSiXG300X1 4.6560e-25
C_4_56 WLR iQ2:SDexcludeXG274UTiSiXG300X1 4.3689e-25
C_4_57 WLR iQ2:SiGeBXG288UTiSiXG299X1 6.6697e-26
C_4_58 WLR iQ2:SiGeBXG290UTiSiXG299X1 9.1026e-28
C_4_59 WLR iQ2:SiGeBXG328UTiSiXG299X1 9.0635e-28
C_4_60 WLR iQ2:SiliconNXG305UTiSiXG300X1 4.7324e-26
C_4_61 WLR iQ2:n1g 1.4476e-24
C_4_62 WLR iQ2:n3d 9.3994e-25
C_4_63 WLR iQ2:n4s 9.3994e-25
C_4_64 WLR iQ2:p1g 1.6753e-24
C_4_65 WLR iQ2:p2s 9.6584e-25
C_4_66 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 7.1224e-19
C_4_67 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 4.2504e-22
C_4_68 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 6.9706e-23
C_4_69 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 6.9677e-23
C_4_70 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:SDexcludeXG264UTiSiXG296X1 1.4298e-20
C_4_71 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:SDexcludeXG271UTiSiXG295X1 5.5906e-21
C_4_72 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:SDexcludeXG272UTiSiXG295X1 6.0795e-21
C_4_73 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:SiGeBXG285UTiSiXG296X1 3.5545e-22
C_4_74 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:SiGeBXG286UTiSiXG296X1 7.3402e-26
C_4_75 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:SiGeBXG323UTiSiXG296X1 6.6489e-26
C_4_76 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:SiGeBXG327UTiSiXG296X1 4.5558e-26
C_4_77 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:SiliconNXG302UTiSiXG295X1 3.0195e-22
C_4_78 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:n1d 1.1972e-20
C_4_79 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:n2s 1.1972e-20
C_4_80 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:n4g 1.4644e-19
C_4_81 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:p1d 1.4653e-20
C_4_82 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ1:p2g 2.8502e-20
C_4_83 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 5.0358e-18
C_4_84 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 1.8678e-18
C_4_85 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 1.7877e-18
C_4_86 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 1.9099e-18
C_4_87 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:SDexcludeXG265UTiSiXG299X1 1.0091e-19
C_4_88 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:SDexcludeXG273UTiSiXG300X1 6.0314e-19
C_4_89 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:SDexcludeXG274UTiSiXG300X1 6.8154e-19
C_4_90 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:SiGeBXG288UTiSiXG299X1 8.0500e-20
C_4_91 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:SiGeBXG290UTiSiXG299X1 1.9215e-22
C_4_92 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:SiGeBXG328UTiSiXG299X1 1.9214e-22
C_4_93 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:SiliconNXG305UTiSiXG300X1 1.1419e-18
C_4_94 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:n1g 1.3902e-20
C_4_95 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:n3d 2.0593e-18
C_4_96 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:n4s 2.0593e-18
C_4_97 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:p1g 1.2189e-20
C_4_98 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 iQ2:p2s 1.8103e-19
C_4_99 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 4.0595e-20
C_4_100 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 1.9999e-24
C_4_101 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.4093e-24
C_4_102 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.4097e-24
C_4_103 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:SDexcludeXG264UTiSiXG296X1 2.4909e-23
C_4_104 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:SDexcludeXG271UTiSiXG295X1 1.0513e-23
C_4_105 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:SDexcludeXG272UTiSiXG295X1 1.1388e-23
C_4_106 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:SiGeBXG285UTiSiXG296X1 5.9121e-25
C_4_107 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:SiGeBXG286UTiSiXG296X1 1.0857e-27
C_4_108 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:SiGeBXG323UTiSiXG296X1 5.6447e-28
C_4_109 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:SiGeBXG327UTiSiXG296X1 5.1380e-28
C_4_110 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:SiliconNXG302UTiSiXG295X1 5.6269e-25
C_4_111 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:n1d 2.2464e-23
C_4_112 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:n2s 2.2464e-23
C_4_113 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:n4g 2.9923e-22
C_4_114 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:p1d 2.5499e-23
C_4_115 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ1:p2g 2.0451e-23
C_4_116 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.7616e-19
C_4_117 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.7405e-19
C_4_118 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.7404e-19
C_4_119 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.7445e-19
C_4_120 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:SDexcludeXG265UTiSiXG299X1 4.0176e-23
C_4_121 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:SDexcludeXG273UTiSiXG300X1 4.5067e-22
C_4_122 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:SDexcludeXG274UTiSiXG300X1 5.6495e-22
C_4_123 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:SiGeBXG288UTiSiXG299X1 1.6259e-24
C_4_124 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:SiGeBXG290UTiSiXG299X1 9.5066e-27
C_4_125 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:SiGeBXG328UTiSiXG299X1 7.3708e-27
C_4_126 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:SiliconNXG305UTiSiXG300X1 1.4169e-21
C_4_127 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:n1g 2.7017e-23
C_4_128 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:n3d 1.2004e-21
C_4_129 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:n4s 1.2004e-21
C_4_130 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:p1g 2.8140e-23
C_4_131 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 iQ2:p2s 4.1787e-23
C_4_132 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 5.0990e-18
C_4_133 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 1.9376e-18
C_4_134 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.9645e-18
C_4_135 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.8580e-18
C_4_136 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:SDexcludeXG264UTiSiXG296X1 1.0131e-19
C_4_137 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:SDexcludeXG271UTiSiXG295X1 6.6525e-19
C_4_138 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:SDexcludeXG272UTiSiXG295X1 5.8980e-19
C_4_139 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:SiGeBXG285UTiSiXG296X1 7.9923e-20
C_4_140 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:SiGeBXG286UTiSiXG296X1 1.6860e-22
C_4_141 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:SiGeBXG323UTiSiXG296X1 1.6859e-22
C_4_142 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:SiGeBXG327UTiSiXG296X1 1.6857e-22
C_4_143 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:SiliconNXG302UTiSiXG295X1 1.1000e-18
C_4_144 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:n1d 2.0350e-18
C_4_145 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:n2s 2.0350e-18
C_4_146 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:n4g 1.3924e-20
C_4_147 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:p1d 1.8089e-19
C_4_148 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ1:p2g 1.2196e-20
C_4_149 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 6.9255e-19
C_4_150 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 4.2363e-22
C_4_151 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 6.7374e-23
C_4_152 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 6.7730e-23
C_4_153 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:SDexcludeXG265UTiSiXG299X1 1.4284e-20
C_4_154 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:SDexcludeXG273UTiSiXG300X1 6.0750e-21
C_4_155 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:SDexcludeXG274UTiSiXG300X1 5.6051e-21
C_4_156 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:SiGeBXG288UTiSiXG299X1 3.5632e-22
C_4_157 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:SiGeBXG290UTiSiXG299X1 5.5558e-26
C_4_158 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:SiGeBXG328UTiSiXG299X1 3.0419e-26
C_4_159 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:SiliconNXG305UTiSiXG300X1 3.0397e-22
C_4_160 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:n1g 1.4503e-19
C_4_161 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:n3d 1.1983e-20
C_4_162 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:n4s 1.1983e-20
C_4_163 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:p1g 2.8370e-20
C_4_164 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 iQ2:p2s 1.4640e-20
C_4_165 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 3.0617e-19
C_4_166 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 3.0443e-19
C_4_167 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 3.0456e-19
C_4_168 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 3.0443e-19
C_4_169 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:SDexcludeXG264UTiSiXG296X1 3.6294e-23
C_4_170 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:SDexcludeXG271UTiSiXG295X1 2.6653e-22
C_4_171 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:SDexcludeXG272UTiSiXG295X1 1.7015e-22
C_4_172 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:SiGeBXG285UTiSiXG296X1 1.4096e-24
C_4_173 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:SiGeBXG286UTiSiXG296X1 7.8059e-27
C_4_174 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:SiGeBXG323UTiSiXG296X1 5.0488e-27
C_4_175 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:SiGeBXG327UTiSiXG296X1 5.0021e-27
C_4_176 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:SiliconNXG302UTiSiXG295X1 6.9450e-22
C_4_177 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:n1d 7.3065e-22
C_4_178 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:n2s 7.3065e-22
C_4_179 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:n4g 2.4580e-23
C_4_180 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:p1d 3.7693e-23
C_4_181 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ1:p2g 2.4862e-23
C_4_182 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 4.5805e-20
C_4_183 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 1.7060e-24
C_4_184 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 1.1667e-24
C_4_185 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 1.1675e-24
C_4_186 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:SDexcludeXG265UTiSiXG299X1 2.2506e-23
C_4_187 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.0318e-23
C_4_188 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:SDexcludeXG274UTiSiXG300X1 9.5112e-24
C_4_189 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:SiGeBXG288UTiSiXG299X1 5.4021e-25
C_4_190 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:SiGeBXG290UTiSiXG299X1 1.0022e-27
C_4_191 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:SiGeBXG328UTiSiXG299X1 5.0203e-28
C_4_192 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:SiliconNXG305UTiSiXG300X1 4.9903e-25
C_4_193 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:n1g 2.5617e-22
C_4_194 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:n3d 2.0324e-23
C_4_195 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:n4s 2.0324e-23
C_4_196 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:p1g 1.8533e-23
C_4_197 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 iQ2:p2s 2.3046e-23
C_4_198 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 5.0291e-22
C_4_199 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 1.1184e-22
C_4_200 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.1173e-22
C_4_201 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.1172e-22
C_4_202 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:SDexcludeXG264UTiSiXG296X1 2.1022e-24
C_4_203 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:SDexcludeXG271UTiSiXG295X1 1.7208e-24
C_4_204 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:SDexcludeXG272UTiSiXG295X1 1.5069e-24
C_4_205 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:SiGeBXG285UTiSiXG296X1 1.1908e-25
C_4_206 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:SiGeBXG286UTiSiXG296X1 1.3737e-27
C_4_207 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:SiGeBXG323UTiSiXG296X1 1.2583e-27
C_4_208 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:SiGeBXG327UTiSiXG296X1 1.2556e-27
C_4_209 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:SiliconNXG302UTiSiXG295X1 1.2080e-25
C_4_210 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:n1d 3.3410e-24
C_4_211 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:n2s 3.3410e-24
C_4_212 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:n4g 2.4218e-24
C_4_213 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:p1d 2.2188e-24
C_4_214 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ1:p2g 2.7898e-24
C_4_215 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 3.3704e-22
C_4_216 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 7.5438e-23
C_4_217 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 7.5341e-23
C_4_218 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 7.5343e-23
C_4_219 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:SDexcludeXG265UTiSiXG299X1 1.6497e-24
C_4_220 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:SDexcludeXG273UTiSiXG300X1 8.1336e-25
C_4_221 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:SDexcludeXG274UTiSiXG300X1 7.6075e-25
C_4_222 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:SiGeBXG288UTiSiXG299X1 9.9314e-26
C_4_223 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:SiGeBXG290UTiSiXG299X1 1.4109e-27
C_4_224 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:SiGeBXG328UTiSiXG299X1 1.4112e-27
C_4_225 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:SiliconNXG305UTiSiXG300X1 6.5761e-26
C_4_226 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:n1g 3.0382e-24
C_4_227 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:n3d 1.6298e-24
C_4_228 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:n4s 1.6298e-24
C_4_229 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:p1g 2.1959e-24
C_4_230 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 iQ2:p2s 1.7462e-24
C_4_231 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 8.3130e-20
C_4_232 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 8.2251e-20
C_4_233 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 8.2260e-20
C_4_234 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 8.2251e-20
C_4_235 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:SDexcludeXG264UTiSiXG296X1 1.0900e-23
C_4_236 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:SDexcludeXG271UTiSiXG295X1 2.8324e-23
C_4_237 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:SDexcludeXG272UTiSiXG295X1 2.0078e-23
C_4_238 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:SiGeBXG285UTiSiXG296X1 4.8381e-25
C_4_239 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:SiGeBXG286UTiSiXG296X1 2.4631e-27
C_4_240 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:SiGeBXG323UTiSiXG296X1 1.6565e-27
C_4_241 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:SiGeBXG327UTiSiXG296X1 1.6427e-27
C_4_242 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:SiliconNXG302UTiSiXG295X1 6.8076e-23
C_4_243 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:n1d 8.7388e-23
C_4_244 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:n2s 8.7388e-23
C_4_245 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:n4g 7.5373e-24
C_4_246 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:p1d 1.1381e-23
C_4_247 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ1:p2g 8.9029e-24
C_4_248 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 3.4875e-20
C_4_249 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 1.0480e-24
C_4_250 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 8.6449e-25
C_4_251 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 8.6458e-25
C_4_252 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:SDexcludeXG265UTiSiXG299X1 6.7458e-24
C_4_253 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:SDexcludeXG273UTiSiXG300X1 3.0492e-24
C_4_254 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:SDexcludeXG274UTiSiXG300X1 2.7633e-24
C_4_255 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:SiGeBXG288UTiSiXG299X1 1.8507e-25
C_4_256 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:SiGeBXG290UTiSiXG299X1 8.4311e-28
C_4_257 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:SiGeBXG328UTiSiXG299X1 7.9735e-28
C_4_258 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:SiliconNXG305UTiSiXG300X1 1.3669e-25
C_4_259 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:n1g 1.2554e-22
C_4_260 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:n3d 5.9466e-24
C_4_261 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:n4s 5.9466e-24
C_4_262 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:p1g 5.4039e-24
C_4_263 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 iQ2:p2s 6.9293e-24
C_4_264 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 3.3023e-22
C_4_265 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 7.4977e-23
C_4_266 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 7.4911e-23
C_4_267 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 7.4909e-23
C_4_268 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:SDexcludeXG264UTiSiXG296X1 1.1218e-24
C_4_269 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:SDexcludeXG271UTiSiXG295X1 5.1330e-25
C_4_270 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:SDexcludeXG272UTiSiXG295X1 5.3889e-25
C_4_271 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:SiGeBXG285UTiSiXG296X1 6.9533e-26
C_4_272 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:SiGeBXG286UTiSiXG296X1 8.5239e-28
C_4_273 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:SiGeBXG323UTiSiXG296X1 8.0277e-28
C_4_274 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:SiGeBXG327UTiSiXG296X1 8.0108e-28
C_4_275 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:SiliconNXG302UTiSiXG295X1 5.1294e-26
C_4_276 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:n1d 1.0964e-24
C_4_277 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:n2s 1.0964e-24
C_4_278 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:n4g 1.9637e-24
C_4_279 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:p1d 1.1898e-24
C_4_280 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ1:p2g 1.7625e-24
C_4_281 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 4.0550e-22
C_4_282 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 9.1227e-23
C_4_283 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 9.1141e-23
C_4_284 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 9.1145e-23
C_4_285 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:SDexcludeXG265UTiSiXG299X1 1.2631e-24
C_4_286 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:SDexcludeXG273UTiSiXG300X1 7.8435e-25
C_4_287 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:SDexcludeXG274UTiSiXG300X1 8.2345e-25
C_4_288 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:SiGeBXG288UTiSiXG299X1 8.8470e-26
C_4_289 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:SiGeBXG290UTiSiXG299X1 1.0549e-27
C_4_290 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:SiGeBXG328UTiSiXG299X1 1.0177e-27
C_4_291 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:SiliconNXG305UTiSiXG300X1 7.5498e-26
C_4_292 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:n1g 1.6565e-24
C_4_293 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:n3d 1.6674e-24
C_4_294 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:n4s 1.6674e-24
C_4_295 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:p1g 2.0726e-24
C_4_296 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 iQ2:p2s 1.3496e-24
C_4_297 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 2.4588e-20
C_4_298 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:LM00Cobalt2XG308USiGeBXG285X1 1.2695e-24
C_4_299 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.0494e-24
C_4_300 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.0497e-24
C_4_301 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:SDexcludeXG264UTiSiXG296X1 9.0303e-24
C_4_302 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:SDexcludeXG271UTiSiXG295X1 3.7178e-24
C_4_303 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:SDexcludeXG272UTiSiXG295X1 4.0492e-24
C_4_304 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:SiGeBXG285UTiSiXG296X1 2.2045e-25
C_4_305 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:SiGeBXG286UTiSiXG296X1 5.3110e-28
C_4_306 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:SiGeBXG323UTiSiXG296X1 3.7466e-28
C_4_307 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:SiGeBXG327UTiSiXG296X1 3.5641e-28
C_4_308 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:SiliconNXG302UTiSiXG295X1 2.0067e-25
C_4_309 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:n1d 7.9676e-24
C_4_310 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:n2s 7.9676e-24
C_4_311 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:n4g 1.0737e-22
C_4_312 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:p1d 9.2501e-24
C_4_313 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ1:p2g 7.2396e-24
C_4_314 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 6.9731e-20
C_4_315 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 6.8535e-20
C_4_316 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 6.8535e-20
C_4_317 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 6.8562e-20
C_4_318 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:SDexcludeXG265UTiSiXG299X1 1.4697e-23
C_4_319 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:SDexcludeXG273UTiSiXG300X1 4.0524e-23
C_4_320 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:SDexcludeXG274UTiSiXG300X1 4.9818e-23
C_4_321 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:SiGeBXG288UTiSiXG299X1 6.8379e-25
C_4_322 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:SiGeBXG290UTiSiXG299X1 4.2706e-27
C_4_323 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:SiGeBXG328UTiSiXG299X1 3.5191e-27
C_4_324 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:SiliconNXG305UTiSiXG300X1 1.0716e-22
C_4_325 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:n1g 9.8445e-24
C_4_326 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:n3d 1.1707e-22
C_4_327 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:n4s 1.1707e-22
C_4_328 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:p1g 1.1951e-23
C_4_329 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 iQ2:p2s 1.5374e-23
C_4_330 WL:n2g iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 3.7184e-19
C_4_331 WL:n2g iQ1:LM00Cobalt2XG308USiGeBXG285X1 1.6539e-19
C_4_332 WL:n2g iQ1:LM00Cobalt2XG308UTiSiXG295X1 2.7661e-19
C_4_333 WL:n2g iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.6539e-19
C_4_334 WL:n2g iQ1:SDexcludeXG264UTiSiXG296X1 3.3057e-24
C_4_335 WL:n2g iQ1:SDexcludeXG271UTiSiXG295X1 1.1122e-19
C_4_336 WL:n2g iQ1:SDexcludeXG272UTiSiXG295X1 1.1122e-19
C_4_337 WL:n2g iQ1:SiGeBXG285UTiSiXG296X1 3.3057e-24
C_4_338 WL:n2g iQ1:SiGeBXG286UTiSiXG296X1 3.3057e-24
C_4_339 WL:n2g iQ1:SiGeBXG323UTiSiXG296X1 3.3057e-24
C_4_340 WL:n2g iQ1:SiGeBXG327UTiSiXG296X1 3.3057e-24
C_4_341 WL:n2g iQ1:SiliconNXG302UTiSiXG295X1 1.1122e-19
C_4_342 WL:n2g iQ1:n4g 8.6502e-21
C_4_343 WL:n2g iQ1:p2g 6.5066e-21
C_4_344 WL:n2g iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.8004e-19
C_4_345 WL:n2g iQ2:LM00Cobalt2XG153USiGeBXG288X1 1.9633e-23
C_4_346 WL:n2g iQ2:LM00Cobalt2XG153UTiSiXG299X1 1.9641e-23
C_4_347 WL:n2g iQ2:LM00Cobalt2XG153UTiSiXG300X1 1.9874e-23
C_4_348 WL:n2g iQ2:SDexcludeXG265UTiSiXG299X1 7.4664e-27
C_4_349 WL:n2g iQ2:SDexcludeXG273UTiSiXG300X1 2.4047e-25
C_4_350 WL:n2g iQ2:SDexcludeXG274UTiSiXG300X1 2.4047e-25
C_4_351 WL:n2g iQ2:SiGeBXG288UTiSiXG299X1 7.4664e-27
C_4_352 WL:n2g iQ2:SiGeBXG290UTiSiXG299X1 7.4664e-27
C_4_353 WL:n2g iQ2:SiGeBXG328UTiSiXG299X1 7.4664e-27
C_4_354 WL:n2g iQ2:SiliconNXG305UTiSiXG300X1 2.4047e-25
C_4_355 WL:n2g iQ2:n1g 7.3474e-20
C_4_356 WL:n2g iQ2:p1g 1.1244e-20
C_4_357 WL:n3g iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 1.8027e-19
C_4_358 WL:n3g iQ1:LM00Cobalt2XG308USiGeBXG285X1 1.9757e-23
C_4_359 WL:n3g iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.9804e-23
C_4_360 WL:n3g iQ1:LM00Cobalt2XG308UTiSiXG296X1 1.9776e-23
C_4_361 WL:n3g iQ1:SDexcludeXG264UTiSiXG296X1 1.9220e-26
C_4_362 WL:n3g iQ1:SDexcludeXG271UTiSiXG295X1 4.6845e-26
C_4_363 WL:n3g iQ1:SDexcludeXG272UTiSiXG295X1 4.6845e-26
C_4_364 WL:n3g iQ1:SiGeBXG285UTiSiXG296X1 1.9220e-26
C_4_365 WL:n3g iQ1:SiGeBXG286UTiSiXG296X1 1.9220e-26
C_4_366 WL:n3g iQ1:SiGeBXG323UTiSiXG296X1 1.9220e-26
C_4_367 WL:n3g iQ1:SiGeBXG327UTiSiXG296X1 1.9220e-26
C_4_368 WL:n3g iQ1:SiliconNXG302UTiSiXG295X1 4.6845e-26
C_4_369 WL:n3g iQ1:n4g 7.3685e-20
C_4_370 WL:n3g iQ1:p2g 1.1272e-20
C_4_371 WL:n3g iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 3.7060e-19
C_4_372 WL:n3g iQ2:LM00Cobalt2XG153USiGeBXG288X1 1.6349e-19
C_4_373 WL:n3g iQ2:LM00Cobalt2XG153UTiSiXG299X1 1.6350e-19
C_4_374 WL:n3g iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.7534e-19
C_4_375 WL:n3g iQ2:SDexcludeXG265UTiSiXG299X1 3.8027e-24
C_4_376 WL:n3g iQ2:SDexcludeXG273UTiSiXG300X1 1.1184e-19
C_4_377 WL:n3g iQ2:SDexcludeXG274UTiSiXG300X1 1.1184e-19
C_4_378 WL:n3g iQ2:SiGeBXG288UTiSiXG299X1 3.8027e-24
C_4_379 WL:n3g iQ2:SiGeBXG290UTiSiXG299X1 3.8027e-24
C_4_380 WL:n3g iQ2:SiGeBXG328UTiSiXG299X1 3.8027e-24
C_4_381 WL:n3g iQ2:SiliconNXG305UTiSiXG300X1 1.1184e-19
C_4_382 WL:n3g iQ2:n1g 8.6561e-21
C_4_383 WL:n3g iQ2:p1g 6.5185e-21
R_4_0 WLL WLR 6.9142e+00
R_4_1 WLL WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 1.5964e+01
R_4_2 WLL WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 3.4771e+02
R_4_3 WLR WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 3.3409e+02
R_4_4 WLR WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 1.6599e+01
R_4_5 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 4.6194e+01
R_4_6 WL:LM00Cobalt2XG101ULM10Tungsten1XG167X1 WL:n3g 3.4278e+01
R_4_7 WL:LM00Cobalt2XG101ULM40Cobalt5XG89X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 5.4672e+01
R_4_8 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 4.6136e+01
R_4_9 WL:LM00Cobalt2XG350ULM10Tungsten1XG367X1 WL:n2g 3.4446e+01
R_4_10 WL:LM00Cobalt2XG350ULM40Cobalt5XG279X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 5.6335e+01
R_4_11 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 WL:LM20Cobalt3XG320ULM40Cobalt5XG279X1 1.2146e+01
R_4_12 WL:LM20Cobalt3XG320ULM30Cobalt4XG123X1 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 1.6801e+04
R_4_13 WL:LM20Cobalt3XG97ULM30Cobalt4XG123X1 WL:LM20Cobalt3XG97ULM40Cobalt5XG89X1 1.2529e+01

*|NET iQ1 1.0888e-04PF
C_5_0 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 6.6895e-18
C_5_1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 3.5720e-18
C_5_2 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.6710e-18
C_5_3 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.7798e-18
C_5_4 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:SDexcludeXG265UTiSiXG299X1 9.6241e-19
C_5_5 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:SDexcludeXG273UTiSiXG300X1 6.6469e-19
C_5_6 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:SDexcludeXG274UTiSiXG300X1 6.5356e-19
C_5_7 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:SiGeBXG288UTiSiXG299X1 9.2072e-19
C_5_8 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:SiGeBXG290UTiSiXG299X1 9.8645e-21
C_5_9 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:SiGeBXG328UTiSiXG299X1 1.0019e-20
C_5_10 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:SiliconNXG305UTiSiXG300X1 1.1441e-18
C_5_11 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:n1g 2.3595e-19
C_5_12 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:n3d 2.1066e-18
C_5_13 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:n4s 2.1066e-18
C_5_14 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:p1g 1.9752e-19
C_5_15 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ2:p2s 1.8634e-18
C_5_16 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 3.6216e-18
C_5_17 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 6.3347e-20
C_5_18 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.5186e-20
C_5_19 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.5092e-20
C_5_20 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:SDexcludeXG265UTiSiXG299X1 5.8710e-21
C_5_21 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.0977e-22
C_5_22 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:SDexcludeXG274UTiSiXG300X1 8.5288e-23
C_5_23 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:SiGeBXG288UTiSiXG299X1 3.8350e-20
C_5_24 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:SiGeBXG290UTiSiXG299X1 9.4425e-23
C_5_25 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:SiGeBXG328UTiSiXG299X1 9.5227e-23
C_5_26 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:SiliconNXG305UTiSiXG300X1 5.9139e-24
C_5_27 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:n1g 1.6486e-19
C_5_28 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:n3d 2.0093e-22
C_5_29 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:n4s 2.0093e-22
C_5_30 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:p1g 8.4638e-20
C_5_31 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ2:p2s 4.4032e-20
C_5_32 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.8180e-18
C_5_33 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.5087e-20
C_5_34 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.2308e-20
C_5_35 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.2268e-20
C_5_36 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:SDexcludeXG265UTiSiXG299X1 2.3954e-22
C_5_37 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:SDexcludeXG273UTiSiXG300X1 9.7568e-24
C_5_38 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:SDexcludeXG274UTiSiXG300X1 8.4337e-24
C_5_39 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:SiGeBXG288UTiSiXG299X1 2.8586e-21
C_5_40 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:SiGeBXG290UTiSiXG299X1 4.0071e-23
C_5_41 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:SiGeBXG328UTiSiXG299X1 4.0460e-23
C_5_42 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:SiliconNXG305UTiSiXG300X1 5.3200e-25
C_5_43 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:n1g 2.7586e-19
C_5_44 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:n3d 1.8695e-23
C_5_45 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:n4s 1.8695e-23
C_5_46 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:p1g 8.4648e-20
C_5_47 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ2:p2s 3.0181e-21
C_5_48 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.7198e-18
C_5_49 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.5161e-20
C_5_50 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.2340e-20
C_5_51 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.2299e-20
C_5_52 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:SDexcludeXG265UTiSiXG299X1 2.4148e-22
C_5_53 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:SDexcludeXG273UTiSiXG300X1 9.7436e-24
C_5_54 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:SDexcludeXG274UTiSiXG300X1 8.4220e-24
C_5_55 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:SiGeBXG288UTiSiXG299X1 2.9018e-21
C_5_56 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:SiGeBXG290UTiSiXG299X1 4.0331e-23
C_5_57 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:SiGeBXG328UTiSiXG299X1 4.0721e-23
C_5_58 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:SiliconNXG305UTiSiXG300X1 5.2857e-25
C_5_59 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:n1g 1.6487e-19
C_5_60 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:n3d 1.8667e-23
C_5_61 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:n4s 1.8667e-23
C_5_62 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:p1g 9.2259e-20
C_5_63 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ2:p2s 3.0626e-21
C_5_64 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 9.6435e-19
C_5_65 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 5.8673e-21
C_5_66 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.3679e-22
C_5_67 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.3453e-22
C_5_68 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:SDexcludeXG265UTiSiXG299X1 2.9984e-20
C_5_69 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:SDexcludeXG273UTiSiXG300X1 3.9813e-21
C_5_70 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:SDexcludeXG274UTiSiXG300X1 3.2763e-21
C_5_71 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:SiGeBXG288UTiSiXG299X1 5.6355e-21
C_5_72 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:SiGeBXG290UTiSiXG299X1 2.5498e-24
C_5_73 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:SiGeBXG328UTiSiXG299X1 2.5231e-24
C_5_74 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:SiliconNXG305UTiSiXG300X1 2.0521e-22
C_5_75 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:n1g 1.3432e-24
C_5_76 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:n3d 7.4620e-21
C_5_77 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:n4s 7.4620e-21
C_5_78 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:p1g 7.6217e-21
C_5_79 iQ1:SDexcludeXG264UTiSiXG296X1 iQ2:p2s 3.5615e-20
C_5_80 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 6.4075e-19
C_5_81 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 8.5258e-23
C_5_82 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 8.3920e-24
C_5_83 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 8.4880e-24
C_5_84 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:SDexcludeXG265UTiSiXG299X1 3.2642e-21
C_5_85 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.5616e-21
C_5_86 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.4653e-21
C_5_87 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:SiGeBXG288UTiSiXG299X1 7.6871e-23
C_5_88 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:SiGeBXG290UTiSiXG299X1 3.7349e-27
C_5_89 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:SiGeBXG328UTiSiXG299X1 2.6426e-27
C_5_90 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:SiliconNXG305UTiSiXG300X1 7.8140e-23
C_5_91 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:n1g 1.1099e-19
C_5_92 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:n3d 3.1047e-21
C_5_93 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:n4s 3.1047e-21
C_5_94 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:p1g 1.0777e-23
C_5_95 iQ1:SDexcludeXG271UTiSiXG295X1 iQ2:p2s 3.3411e-21
C_5_96 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 6.5278e-19
C_5_97 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 1.1013e-22
C_5_98 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 9.7645e-24
C_5_99 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 9.8690e-24
C_5_100 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:SDexcludeXG265UTiSiXG299X1 3.9807e-21
C_5_101 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.6951e-21
C_5_102 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.5666e-21
C_5_103 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:SiGeBXG288UTiSiXG299X1 1.0038e-22
C_5_104 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:SiGeBXG290UTiSiXG299X1 6.2814e-27
C_5_105 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:SiGeBXG328UTiSiXG299X1 3.2755e-27
C_5_106 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:SiliconNXG305UTiSiXG300X1 8.4941e-23
C_5_107 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:n1g 1.1099e-19
C_5_108 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:n3d 3.3463e-21
C_5_109 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:n4s 3.3463e-21
C_5_110 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:p1g 1.0777e-23
C_5_111 iQ1:SDexcludeXG272UTiSiXG295X1 iQ2:p2s 4.0811e-21
C_5_112 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 9.1915e-19
C_5_113 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 3.8334e-20
C_5_114 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 2.9091e-21
C_5_115 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.8545e-21
C_5_116 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:SDexcludeXG265UTiSiXG299X1 5.6335e-21
C_5_117 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.0004e-22
C_5_118 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:SDexcludeXG274UTiSiXG300X1 7.6881e-23
C_5_119 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:SiGeBXG288UTiSiXG299X1 3.5534e-20
C_5_120 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:SiGeBXG290UTiSiXG299X1 5.4614e-23
C_5_121 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:SiGeBXG328UTiSiXG299X1 5.5029e-23
C_5_122 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:SiliconNXG305UTiSiXG300X1 5.3863e-24
C_5_123 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:n1g 1.3432e-24
C_5_124 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:n3d 1.8229e-22
C_5_125 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:n4s 1.8229e-22
C_5_126 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:p1g 7.6217e-21
C_5_127 iQ1:SiGeBXG285UTiSiXG296X1 iQ2:p2s 4.1058e-20
C_5_128 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 8.7868e-21
C_5_129 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 7.3986e-23
C_5_130 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 3.1369e-23
C_5_131 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 3.1109e-23
C_5_132 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:SDexcludeXG265UTiSiXG299X1 2.0490e-24
C_5_133 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.1378e-26
C_5_134 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:SDexcludeXG274UTiSiXG300X1 8.5993e-27
C_5_135 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:SiGeBXG288UTiSiXG299X1 4.3137e-23
C_5_136 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:SiGeBXG290UTiSiXG299X1 2.6034e-25
C_5_137 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:SiGeBXG328UTiSiXG299X1 2.6194e-25
C_5_138 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:SiliconNXG305UTiSiXG300X1 1.1615e-27
C_5_139 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:n1g 1.3432e-24
C_5_140 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:n3d 2.1078e-26
C_5_141 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:n4s 2.1078e-26
C_5_142 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:p1g 7.6217e-21
C_5_143 iQ1:SiGeBXG286UTiSiXG296X1 iQ2:p2s 4.4667e-23
C_5_144 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 8.6957e-21
C_5_145 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 7.3979e-23
C_5_146 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 3.1364e-23
C_5_147 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 3.1105e-23
C_5_148 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:SDexcludeXG265UTiSiXG299X1 2.0031e-24
C_5_149 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:SDexcludeXG273UTiSiXG300X1 1.4086e-26
C_5_150 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.3734e-26
C_5_151 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:SiGeBXG288UTiSiXG299X1 4.3134e-23
C_5_152 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:SiGeBXG290UTiSiXG299X1 2.5989e-25
C_5_153 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:SiGeBXG328UTiSiXG299X1 2.6149e-25
C_5_154 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:SiliconNXG305UTiSiXG300X1 7.5576e-28
C_5_155 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:n1g 1.3432e-24
C_5_156 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:n3d 2.8529e-26
C_5_157 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:n4s 2.8529e-26
C_5_158 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:p1g 7.6217e-21
C_5_159 iQ1:SiGeBXG323UTiSiXG296X1 iQ2:p2s 4.4618e-23
C_5_160 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 8.6957e-21
C_5_161 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 7.3979e-23
C_5_162 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 3.1364e-23
C_5_163 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 3.1105e-23
C_5_164 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:SDexcludeXG265UTiSiXG299X1 1.9987e-24
C_5_165 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:SDexcludeXG273UTiSiXG300X1 8.5176e-27
C_5_166 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:SDexcludeXG274UTiSiXG300X1 7.7428e-27
C_5_167 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:SiGeBXG288UTiSiXG299X1 4.3134e-23
C_5_168 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:SiGeBXG290UTiSiXG299X1 2.5989e-25
C_5_169 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:SiGeBXG328UTiSiXG299X1 2.6148e-25
C_5_170 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:SiliconNXG305UTiSiXG300X1 5.1273e-28
C_5_171 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:n1g 1.3432e-24
C_5_172 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:n3d 1.6728e-26
C_5_173 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:n4s 1.6728e-26
C_5_174 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:p1g 7.6217e-21
C_5_175 iQ1:SiGeBXG327UTiSiXG296X1 iQ2:p2s 4.4613e-23
C_5_176 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.1217e-18
C_5_177 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:LM00Cobalt2XG153USiGeBXG288X1 5.8596e-24
C_5_178 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 5.0786e-25
C_5_179 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 5.0787e-25
C_5_180 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:SDexcludeXG265UTiSiXG299X1 2.0373e-22
C_5_181 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:SDexcludeXG273UTiSiXG300X1 8.4324e-23
C_5_182 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:SDexcludeXG274UTiSiXG300X1 7.7834e-23
C_5_183 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:SiGeBXG288UTiSiXG299X1 5.3521e-24
C_5_184 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:SiGeBXG290UTiSiXG299X1 8.1490e-28
C_5_185 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:SiGeBXG328UTiSiXG299X1 1.8069e-28
C_5_186 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:SiliconNXG305UTiSiXG300X1 4.3038e-24
C_5_187 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:n1g 1.1099e-19
C_5_188 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:n3d 1.6646e-22
C_5_189 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:n4s 1.6646e-22
C_5_190 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:p1g 1.0777e-23
C_5_191 iQ1:SiliconNXG302UTiSiXG295X1 iQ2:p2s 2.0908e-22
C_5_192 iQ1:n1d iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.0945e-18
C_5_193 iQ1:n1d iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.0122e-22
C_5_194 iQ1:n1d iQ2:LM00Cobalt2XG153UTiSiXG299X1 1.8640e-23
C_5_195 iQ1:n1d iQ2:LM00Cobalt2XG153UTiSiXG300X1 1.8841e-23
C_5_196 iQ1:n1d iQ2:SDexcludeXG265UTiSiXG299X1 7.4485e-21
C_5_197 iQ1:n1d iQ2:SDexcludeXG273UTiSiXG300X1 3.3410e-21
C_5_198 iQ1:n1d iQ2:SDexcludeXG274UTiSiXG300X1 3.1097e-21
C_5_199 iQ1:n1d iQ2:SiGeBXG288UTiSiXG299X1 1.8259e-22
C_5_200 iQ1:n1d iQ2:SiGeBXG290UTiSiXG299X1 1.0811e-26
C_5_201 iQ1:n1d iQ2:SiGeBXG328UTiSiXG299X1 6.0908e-27
C_5_202 iQ1:n1d iQ2:SiliconNXG305UTiSiXG300X1 1.6737e-22
C_5_203 iQ1:n1d iQ2:n3d 6.6174e-21
C_5_204 iQ1:n1d iQ2:n4s 6.6174e-21
C_5_205 iQ1:n1d iQ2:p2s 7.6311e-21
C_5_206 iQ1:n2s iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.0945e-18
C_5_207 iQ1:n2s iQ2:LM00Cobalt2XG153USiGeBXG288X1 2.0122e-22
C_5_208 iQ1:n2s iQ2:LM00Cobalt2XG153UTiSiXG299X1 1.8640e-23
C_5_209 iQ1:n2s iQ2:LM00Cobalt2XG153UTiSiXG300X1 1.8841e-23
C_5_210 iQ1:n2s iQ2:SDexcludeXG265UTiSiXG299X1 7.4485e-21
C_5_211 iQ1:n2s iQ2:SDexcludeXG273UTiSiXG300X1 3.3410e-21
C_5_212 iQ1:n2s iQ2:SDexcludeXG274UTiSiXG300X1 3.1097e-21
C_5_213 iQ1:n2s iQ2:SiGeBXG288UTiSiXG299X1 1.8259e-22
C_5_214 iQ1:n2s iQ2:SiGeBXG290UTiSiXG299X1 1.0811e-26
C_5_215 iQ1:n2s iQ2:SiGeBXG328UTiSiXG299X1 6.0908e-27
C_5_216 iQ1:n2s iQ2:SiliconNXG305UTiSiXG300X1 1.6737e-22
C_5_217 iQ1:n2s iQ2:n3d 6.6174e-21
C_5_218 iQ1:n2s iQ2:n4s 6.6174e-21
C_5_219 iQ1:n2s iQ2:p2s 7.6311e-21
C_5_220 iQ1:n4g iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 2.3407e-19
C_5_221 iQ1:n4g iQ2:LM00Cobalt2XG153USiGeBXG288X1 1.6275e-19
C_5_222 iQ1:n4g iQ2:LM00Cobalt2XG153UTiSiXG299X1 1.6275e-19
C_5_223 iQ1:n4g iQ2:LM00Cobalt2XG153UTiSiXG300X1 2.7430e-19
C_5_224 iQ1:n4g iQ2:SDexcludeXG265UTiSiXG299X1 1.5615e-24
C_5_225 iQ1:n4g iQ2:SDexcludeXG273UTiSiXG300X1 1.1155e-19
C_5_226 iQ1:n4g iQ2:SDexcludeXG274UTiSiXG300X1 1.1155e-19
C_5_227 iQ1:n4g iQ2:SiGeBXG288UTiSiXG299X1 1.5615e-24
C_5_228 iQ1:n4g iQ2:SiGeBXG290UTiSiXG299X1 1.5615e-24
C_5_229 iQ1:n4g iQ2:SiGeBXG328UTiSiXG299X1 1.5615e-24
C_5_230 iQ1:n4g iQ2:SiliconNXG305UTiSiXG300X1 1.1155e-19
C_5_231 iQ1:n4g iQ2:n1g 8.2899e-21
C_5_232 iQ1:n4g iQ2:p1g 5.4294e-21
C_5_233 iQ1:p1d iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.8661e-18
C_5_234 iQ1:p1d iQ2:LM00Cobalt2XG153USiGeBXG288X1 4.4053e-20
C_5_235 iQ1:p1d iQ2:LM00Cobalt2XG153UTiSiXG299X1 3.0832e-21
C_5_236 iQ1:p1d iQ2:LM00Cobalt2XG153UTiSiXG300X1 3.0268e-21
C_5_237 iQ1:p1d iQ2:SDexcludeXG265UTiSiXG299X1 3.5614e-20
C_5_238 iQ1:p1d iQ2:SDexcludeXG273UTiSiXG300X1 4.0813e-21
C_5_239 iQ1:p1d iQ2:SDexcludeXG274UTiSiXG300X1 3.3531e-21
C_5_240 iQ1:p1d iQ2:SiGeBXG288UTiSiXG299X1 4.1083e-20
C_5_241 iQ1:p1d iQ2:SiGeBXG290UTiSiXG299X1 5.6644e-23
C_5_242 iQ1:p1d iQ2:SiGeBXG328UTiSiXG299X1 5.7030e-23
C_5_243 iQ1:p1d iQ2:SiliconNXG305UTiSiXG300X1 2.1060e-22
C_5_244 iQ1:p1d iQ2:n3d 7.6442e-21
C_5_245 iQ1:p1d iQ2:n4s 7.6442e-21
C_5_246 iQ1:p1d iQ2:p2s 7.6584e-20
C_5_247 iQ1:p2g iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 1.9755e-19
C_5_248 iQ1:p2g iQ2:LM00Cobalt2XG153USiGeBXG288X1 8.4337e-20
C_5_249 iQ1:p2g iQ2:LM00Cobalt2XG153UTiSiXG299X1 9.2662e-20
C_5_250 iQ1:p2g iQ2:LM00Cobalt2XG153UTiSiXG300X1 8.4349e-20
C_5_251 iQ1:p2g iQ2:SDexcludeXG265UTiSiXG299X1 8.3246e-21
C_5_252 iQ1:p2g iQ2:SDexcludeXG273UTiSiXG300X1 1.1347e-23
C_5_253 iQ1:p2g iQ2:SDexcludeXG274UTiSiXG300X1 1.1347e-23
C_5_254 iQ1:p2g iQ2:SiGeBXG288UTiSiXG299X1 8.3246e-21
C_5_255 iQ1:p2g iQ2:SiGeBXG290UTiSiXG299X1 8.3246e-21
C_5_256 iQ1:p2g iQ2:SiGeBXG328UTiSiXG299X1 8.3246e-21
C_5_257 iQ1:p2g iQ2:SiliconNXG305UTiSiXG300X1 1.1347e-23
C_5_258 iQ1:p2g iQ2:n1g 5.4173e-21
C_5_259 iQ1:p2g iQ2:p1g 6.4192e-21
R_5_0 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ1:LM00Cobalt2XG308UTiSiXG295X1 1.1665e+02
R_5_1 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 6.1996e+01
R_5_2 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ1:n4g 2.0672e+03
R_5_3 iQ1:LM00Cobalt2XG308ULM10Tungsten1XG368X1 iQ1:p2g 6.4583e+01
R_5_4 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 0.0000e+00
R_5_5 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ1:SDexcludeXG264UTiSiXG296X1 4.9114e+04
R_5_6 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ1:SiGeBXG285UTiSiXG296X1 0.0000e+00
R_5_7 iQ1:LM00Cobalt2XG308USiGeBXG285X1 iQ1:p1d 2.3254e+03
R_5_8 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ1:LM00Cobalt2XG308UTiSiXG296X1 3.4199e+01
R_5_9 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ1:SDexcludeXG271UTiSiXG295X1 3.1571e+04
R_5_10 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ1:SDexcludeXG272UTiSiXG295X1 3.4738e+04
R_5_11 iQ1:LM00Cobalt2XG308UTiSiXG295X1 iQ1:SiliconNXG302UTiSiXG295X1 9.2898e+01
R_5_12 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ1:SDexcludeXG264UTiSiXG296X1 7.6220e+02
R_5_13 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ1:SiGeBXG285UTiSiXG296X1 0.0000e+00
R_5_14 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ1:SiGeBXG323UTiSiXG296X1 1.9296e+03
R_5_15 iQ1:LM00Cobalt2XG308UTiSiXG296X1 iQ1:SiGeBXG327UTiSiXG296X1 2.2843e+03
R_5_16 iQ1:SDexcludeXG264UTiSiXG296X1 iQ1:SiGeBXG285UTiSiXG296X1 0.0000e+00
R_5_17 iQ1:SDexcludeXG264UTiSiXG296X1 iQ1:SiGeBXG286UTiSiXG296X1 0.0000e+00
R_5_18 iQ1:SDexcludeXG264UTiSiXG296X1 iQ1:SiGeBXG323UTiSiXG296X1 0.0000e+00
R_5_19 iQ1:SDexcludeXG264UTiSiXG296X1 iQ1:SiGeBXG327UTiSiXG296X1 0.0000e+00
R_5_20 iQ1:SDexcludeXG264UTiSiXG296X1 iQ1:p1d 7.7493e+03
R_5_21 iQ1:SDexcludeXG271UTiSiXG295X1 iQ1:SDexcludeXG272UTiSiXG295X1 1.3356e+03
R_5_22 iQ1:SDexcludeXG271UTiSiXG295X1 iQ1:SiliconNXG302UTiSiXG295X1 0.0000e+00
R_5_23 iQ1:SDexcludeXG271UTiSiXG295X1 iQ1:n1d 3.0162e+02
R_5_24 iQ1:SDexcludeXG271UTiSiXG295X1 iQ1:n2s 3.0162e+02
R_5_25 iQ1:SDexcludeXG272UTiSiXG295X1 iQ1:SiliconNXG302UTiSiXG295X1 0.0000e+00
R_5_26 iQ1:SDexcludeXG272UTiSiXG295X1 iQ1:n1d 2.7602e+02
R_5_27 iQ1:SDexcludeXG272UTiSiXG295X1 iQ1:n2s 2.7602e+02
R_5_28 iQ1:SiGeBXG285UTiSiXG296X1 iQ1:SiGeBXG286UTiSiXG296X1 0.0000e+00
R_5_29 iQ1:SiGeBXG285UTiSiXG296X1 iQ1:SiGeBXG323UTiSiXG296X1 0.0000e+00
R_5_30 iQ1:SiGeBXG285UTiSiXG296X1 iQ1:SiGeBXG327UTiSiXG296X1 0.0000e+00
R_5_31 iQ1:SiGeBXG285UTiSiXG296X1 iQ1:p1d 2.4514e+01
R_5_32 iQ1:SiliconNXG302UTiSiXG295X1 iQ1:n1d 3.1582e+01
R_5_33 iQ1:SiliconNXG302UTiSiXG295X1 iQ1:n2s 3.1582e+01
R_5_34 iQ1:n1d iQ1:n2s 0.0000e+00
R_5_35 iQ1:n4g iQ1:p2g 5.6689e+01

*|NET iQ2 1.0850e-04PF
R_6_0 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 6.2582e+01
R_6_1 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 1.1771e+02
R_6_2 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 iQ2:n1g 2.0782e+03
R_6_3 iQ2:LM00Cobalt2XG153ULM10Tungsten1XG151X1 iQ2:p1g 6.4687e+01
R_6_4 iQ2:LM00Cobalt2XG153USiGeBXG288X1 iQ2:LM00Cobalt2XG153UTiSiXG299X1 0.0000e+00
R_6_5 iQ2:LM00Cobalt2XG153USiGeBXG288X1 iQ2:SDexcludeXG265UTiSiXG299X1 5.1920e+04
R_6_6 iQ2:LM00Cobalt2XG153USiGeBXG288X1 iQ2:SiGeBXG288UTiSiXG299X1 0.0000e+00
R_6_7 iQ2:LM00Cobalt2XG153USiGeBXG288X1 iQ2:p2s 1.9444e+03
R_6_8 iQ2:LM00Cobalt2XG153UTiSiXG299X1 iQ2:LM00Cobalt2XG153UTiSiXG300X1 3.4248e+01
R_6_9 iQ2:LM00Cobalt2XG153UTiSiXG299X1 iQ2:SDexcludeXG265UTiSiXG299X1 1.1402e+03
R_6_10 iQ2:LM00Cobalt2XG153UTiSiXG299X1 iQ2:SiGeBXG288UTiSiXG299X1 0.0000e+00
R_6_11 iQ2:LM00Cobalt2XG153UTiSiXG299X1 iQ2:SiGeBXG290UTiSiXG299X1 2.2639e+03
R_6_12 iQ2:LM00Cobalt2XG153UTiSiXG300X1 iQ2:SDexcludeXG273UTiSiXG300X1 3.3090e+04
R_6_13 iQ2:LM00Cobalt2XG153UTiSiXG300X1 iQ2:SDexcludeXG274UTiSiXG300X1 3.3835e+04
R_6_14 iQ2:LM00Cobalt2XG153UTiSiXG300X1 iQ2:SiliconNXG305UTiSiXG300X1 9.4684e+01
R_6_15 iQ2:SDexcludeXG265UTiSiXG299X1 iQ2:SiGeBXG288UTiSiXG299X1 0.0000e+00
R_6_16 iQ2:SDexcludeXG265UTiSiXG299X1 iQ2:SiGeBXG290UTiSiXG299X1 0.0000e+00
R_6_17 iQ2:SDexcludeXG265UTiSiXG299X1 iQ2:SiGeBXG328UTiSiXG299X1 0.0000e+00
R_6_18 iQ2:SDexcludeXG265UTiSiXG299X1 iQ2:p2s 1.3254e+04
R_6_19 iQ2:SDexcludeXG273UTiSiXG300X1 iQ2:SDexcludeXG274UTiSiXG300X1 1.3126e+03
R_6_20 iQ2:SDexcludeXG273UTiSiXG300X1 iQ2:SiliconNXG305UTiSiXG300X1 0.0000e+00
R_6_21 iQ2:SDexcludeXG273UTiSiXG300X1 iQ2:n3d 2.9562e+02
R_6_22 iQ2:SDexcludeXG273UTiSiXG300X1 iQ2:n4s 2.9562e+02
R_6_23 iQ2:SDexcludeXG274UTiSiXG300X1 iQ2:SiliconNXG305UTiSiXG300X1 0.0000e+00
R_6_24 iQ2:SDexcludeXG274UTiSiXG300X1 iQ2:n3d 2.7949e+02
R_6_25 iQ2:SDexcludeXG274UTiSiXG300X1 iQ2:n4s 2.7949e+02
R_6_26 iQ2:SiGeBXG288UTiSiXG299X1 iQ2:SiGeBXG290UTiSiXG299X1 0.0000e+00
R_6_27 iQ2:SiGeBXG288UTiSiXG299X1 iQ2:SiGeBXG328UTiSiXG299X1 0.0000e+00
R_6_28 iQ2:SiGeBXG288UTiSiXG299X1 iQ2:p2s 2.4463e+01
R_6_29 iQ2:SiliconNXG305UTiSiXG300X1 iQ2:n3d 3.1512e+01
R_6_30 iQ2:SiliconNXG305UTiSiXG300X1 iQ2:n4s 3.1512e+01
R_6_31 iQ2:n1g iQ2:p1g 5.6670e+01
R_6_32 iQ2:n3d iQ2:n4s 0.0000e+00

*|INSTANCES
XMP1 iQ1:p1d iQ2:p1g VDD:p1s VBP pmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMP1_delta/(1**0.5)'
XMP2 VDD:p2d iQ1:p2g iQ2:p2s VBP pmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMP2_delta/(1**0.5)'
XMN1 iQ1:n1d iQ2:n1g VSS:n1s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 2 delvtrand0='XMN1_delta/(2**0.5)'
XMN2 BL:n2d WL:n2g iQ1:n2s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 2 delvtrand0='XMN2_delta/(2**0.5)'
XMN3 iQ2:n3d WL:n3g BLB:n3s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 2 delvtrand0='XMN3_delta/(2**0.5)'
XMN4 VSS:n4d iQ1:n4g iQ2:n4s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 2 delvtrand0='XMN4_delta/(2**0.5)'

.ENDS array
