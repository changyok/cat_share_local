*|TITLE Netlist generated by Raphael FX rcnetmerge
*|TITLE 1.1
*|TITLE Date Fri Apr 23 15:29:59 PDT 2021
*|PARAM cellnamefrom= raphaelfx
*|PARAM include= {}
*|PARAM instancefrom= raphaelnet
*|PARAM outputnet= n943_rph.spf
*|PARAM pingroup=  WL {WLL WLR} BL {BLU BLD} BLB {BLBU BLBD}
*|PARAM pinsfrom= raphaelfx
*|PARAM raphaelnet= n943_rph.spi
*|PARAM referencenet= /nfs/pdx/disks/icf_sandp_gwa001/changyok/swb/SNPS_DTCO/TRD2/20201220/BIC2022_update20210412/2-RC_Extraction/2.01-BIC2022_FinFET_PEX_Nominal/sram_hd_wide.lvs

.SUBCKT array_flat BLBD BLBU BLD BLU VDD VSS WLL WLR VBP VBN

*|NETS BL BLB VDD VSS WL iQ1 iQ2

*|CAPACITANCE GRAND SUM 2.4250e-04PF
*|BLB WL 1.8412e-05PF
*|BLB iQ1 7.0262e-07PF
*|BLB iQ2 5.1015e-06PF
*|BL BLB 8.6550e-08PF
*|BL WL 1.8054e-05PF
*|BL iQ1 5.0802e-06PF
*|BL iQ2 6.7288e-07PF
*|VDD BL 1.1174e-05PF
*|VDD BLB 1.1189e-05PF
*|VDD VSS 1.0262e-05PF
*|VDD WL 6.8374e-06PF
*|VDD iQ1 1.3542e-05PF
*|VDD iQ2 1.3891e-05PF
*|VSS BL 7.6847e-06PF
*|VSS BLB 7.9724e-06PF
*|VSS WL 1.8895e-05PF
*|VSS iQ1 1.0060e-05PF
*|VSS iQ2 1.0434e-05PF
*|WL iQ1 1.6089e-05PF
*|WL iQ2 1.6283e-05PF
*|iQ1 iQ2 4.0074e-05PF

*|NET BL 4.2753e-05PF
C_0_0 BLBD BLD 1.9537e-21
C_0_1 BLBD BLU 1.9537e-21
C_0_2 BLBD BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 2.9103e-21
C_0_3 BLBD BL:LM00Cobalt2XG481UTiSiXG473X1 9.6512e-22
C_0_4 BLBD BL:SiliconNXG468UTiSiXG473X1 2.0584e-22
C_0_5 BLBD BL:n2d 3.1358e-22
C_0_6 BLBU BLD 1.9537e-21
C_0_7 BLBU BLU 1.9537e-21
C_0_8 BLBU BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 2.9103e-21
C_0_9 BLBU BL:LM00Cobalt2XG481UTiSiXG473X1 9.6512e-22
C_0_10 BLBU BL:SiliconNXG468UTiSiXG473X1 2.0584e-22
C_0_11 BLBU BL:n2d 3.1358e-22
C_0_12 BLD WLL 2.9110e-19
C_0_13 BLD WLR 2.9110e-19
C_0_14 BLD BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 2.9272e-21
C_0_15 BLD BLB:LM00Cobalt2XG64UTiSiXG68X1 9.8205e-22
C_0_16 BLD BLB:SiliconNXG67UTiSiXG68X1 2.0406e-22
C_0_17 BLD BLB:n3s 3.1213e-22
C_0_18 BLD WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.3769e-19
C_0_19 BLD WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 7.4183e-19
C_0_20 BLD WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 2.3896e-22
C_0_21 BLD WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 5.2655e-23
C_0_22 BLD WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 4.2266e-19
C_0_23 BLD WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 8.0938e-19
C_0_24 BLD WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 2.9111e-19
C_0_25 BLD WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 4.9039e-23
C_0_26 BLD WL:n2g 6.0640e-22
C_0_27 BLD WL:n3g 3.4660e-23
C_0_28 BLD iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 2.2266e-19
C_0_29 BLD iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.9163e-19
C_0_30 BLD iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.9162e-19
C_0_31 BLD iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.9161e-19
C_0_32 BLD iQ1:SDexcludeXG241UTiSiXG270X1 6.9084e-23
C_0_33 BLD iQ1:SDexcludeXG245UTiSiXG269X1 6.7031e-23
C_0_34 BLD iQ1:SiGeBXG256UTiSiXG270X1 1.8154e-23
C_0_35 BLD iQ1:SiGeBXG257UTiSiXG270X1 6.5250e-25
C_0_36 BLD iQ1:SiGeBXG260UTiSiXG270X1 6.5058e-25
C_0_37 BLD iQ1:SiGeBXG286UTiSiXG270X1 6.7951e-25
C_0_38 BLD iQ1:SiGeBXG290UTiSiXG270X1 6.4778e-25
C_0_39 BLD iQ1:SiliconNXG274UTiSiXG269X1 5.5021e-23
C_0_40 BLD iQ1:n1d 9.3897e-23
C_0_41 BLD iQ1:n2s 9.3897e-23
C_0_42 BLD iQ1:n4g 3.1358e-23
C_0_43 BLD iQ1:p1d 8.5943e-23
C_0_44 BLD iQ1:p2g 9.2533e-23
C_0_45 BLD iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.3577e-19
C_0_46 BLD iQ2:LM00Cobalt2XG118USiGeBXG261X1 6.1339e-22
C_0_47 BLD iQ2:LM00Cobalt2XG118UTiSiXG271X1 6.0707e-22
C_0_48 BLD iQ2:LM00Cobalt2XG118UTiSiXG272X1 6.0698e-22
C_0_49 BLD iQ2:SDexcludeXG242UTiSiXG271X1 4.4368e-23
C_0_50 BLD iQ2:SDexcludeXG246UTiSiXG272X1 2.0948e-23
C_0_51 BLD iQ2:SiGeBXG261UTiSiXG271X1 6.5110e-24
C_0_52 BLD iQ2:SiGeBXG262UTiSiXG271X1 9.3325e-26
C_0_53 BLD iQ2:SiGeBXG265UTiSiXG271X1 9.3045e-26
C_0_54 BLD iQ2:SiliconNXG276UTiSiXG272X1 8.7926e-25
C_0_55 BLD iQ2:n1g 3.7083e-22
C_0_56 BLD iQ2:n3d 2.1809e-23
C_0_57 BLD iQ2:n4s 2.1809e-23
C_0_58 BLD iQ2:p1g 1.7973e-22
C_0_59 BLD iQ2:p2s 5.0693e-23
C_0_60 BLU WLL 2.9110e-19
C_0_61 BLU WLR 2.9110e-19
C_0_62 BLU BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 2.9272e-21
C_0_63 BLU BLB:LM00Cobalt2XG64UTiSiXG68X1 9.8205e-22
C_0_64 BLU BLB:SiliconNXG67UTiSiXG68X1 2.0406e-22
C_0_65 BLU BLB:n3s 3.1213e-22
C_0_66 BLU WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.3769e-19
C_0_67 BLU WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 7.4183e-19
C_0_68 BLU WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 2.3896e-22
C_0_69 BLU WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 5.2655e-23
C_0_70 BLU WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 4.2266e-19
C_0_71 BLU WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 8.0938e-19
C_0_72 BLU WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 2.9111e-19
C_0_73 BLU WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 4.9039e-23
C_0_74 BLU WL:n2g 6.0640e-22
C_0_75 BLU WL:n3g 3.4660e-23
C_0_76 BLU iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 2.2266e-19
C_0_77 BLU iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.9163e-19
C_0_78 BLU iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.9162e-19
C_0_79 BLU iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.9161e-19
C_0_80 BLU iQ1:SDexcludeXG241UTiSiXG270X1 6.9084e-23
C_0_81 BLU iQ1:SDexcludeXG245UTiSiXG269X1 6.7031e-23
C_0_82 BLU iQ1:SiGeBXG256UTiSiXG270X1 1.8154e-23
C_0_83 BLU iQ1:SiGeBXG257UTiSiXG270X1 6.5250e-25
C_0_84 BLU iQ1:SiGeBXG260UTiSiXG270X1 6.5058e-25
C_0_85 BLU iQ1:SiGeBXG286UTiSiXG270X1 6.7951e-25
C_0_86 BLU iQ1:SiGeBXG290UTiSiXG270X1 6.4778e-25
C_0_87 BLU iQ1:SiliconNXG274UTiSiXG269X1 5.5021e-23
C_0_88 BLU iQ1:n1d 9.3897e-23
C_0_89 BLU iQ1:n2s 9.3897e-23
C_0_90 BLU iQ1:n4g 3.1358e-23
C_0_91 BLU iQ1:p1d 8.5943e-23
C_0_92 BLU iQ1:p2g 9.2533e-23
C_0_93 BLU iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.3577e-19
C_0_94 BLU iQ2:LM00Cobalt2XG118USiGeBXG261X1 6.1339e-22
C_0_95 BLU iQ2:LM00Cobalt2XG118UTiSiXG271X1 6.0707e-22
C_0_96 BLU iQ2:LM00Cobalt2XG118UTiSiXG272X1 6.0698e-22
C_0_97 BLU iQ2:SDexcludeXG242UTiSiXG271X1 4.4368e-23
C_0_98 BLU iQ2:SDexcludeXG246UTiSiXG272X1 2.0948e-23
C_0_99 BLU iQ2:SiGeBXG261UTiSiXG271X1 6.5110e-24
C_0_100 BLU iQ2:SiGeBXG262UTiSiXG271X1 9.3325e-26
C_0_101 BLU iQ2:SiGeBXG265UTiSiXG271X1 9.3045e-26
C_0_102 BLU iQ2:SiliconNXG276UTiSiXG272X1 8.7926e-25
C_0_103 BLU iQ2:n1g 3.7083e-22
C_0_104 BLU iQ2:n3d 2.1809e-23
C_0_105 BLU iQ2:n4s 2.1809e-23
C_0_106 BLU iQ2:p1g 1.7973e-22
C_0_107 BLU iQ2:p2s 5.0693e-23
C_0_108 WLL BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 2.9324e-19
C_0_109 WLL BL:LM00Cobalt2XG481UTiSiXG473X1 2.1480e-21
C_0_110 WLL BL:SiliconNXG468UTiSiXG473X1 8.6436e-23
C_0_111 WLL BL:n2d 9.3128e-23
C_0_112 WLR BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 2.9324e-19
C_0_113 WLR BL:LM00Cobalt2XG481UTiSiXG473X1 2.1480e-21
C_0_114 WLR BL:SiliconNXG468UTiSiXG473X1 8.6436e-23
C_0_115 WLR BL:n2d 9.3128e-23
C_0_116 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 3.9022e-21
C_0_117 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 1.0012e-21
C_0_118 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 BLB:SiliconNXG67UTiSiXG68X1 3.3477e-22
C_0_119 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 BLB:n3s 1.1418e-21
C_0_120 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.3260e-18
C_0_121 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 1.0447e-18
C_0_122 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 9.8127e-22
C_0_123 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 5.4003e-23
C_0_124 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 4.3738e-19
C_0_125 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 9.5579e-19
C_0_126 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 2.9325e-19
C_0_127 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 4.9610e-23
C_0_128 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 WL:n2g 7.9001e-20
C_0_129 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 WL:n3g 3.1230e-22
C_0_130 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 7.0343e-19
C_0_131 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 2.6126e-19
C_0_132 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 2.6102e-19
C_0_133 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 2.6099e-19
C_0_134 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:SDexcludeXG241UTiSiXG270X1 1.0057e-21
C_0_135 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:SDexcludeXG245UTiSiXG269X1 7.0040e-22
C_0_136 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:SiGeBXG256UTiSiXG270X1 2.7623e-22
C_0_137 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:SiGeBXG257UTiSiXG270X1 3.4140e-24
C_0_138 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:SiGeBXG260UTiSiXG270X1 3.3944e-24
C_0_139 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:SiGeBXG286UTiSiXG270X1 3.4753e-24
C_0_140 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:SiGeBXG290UTiSiXG270X1 3.3925e-24
C_0_141 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:SiliconNXG274UTiSiXG269X1 2.3917e-22
C_0_142 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:n1d 8.7030e-22
C_0_143 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:n2s 8.7030e-22
C_0_144 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:n4g 4.3905e-22
C_0_145 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:p1d 1.2751e-21
C_0_146 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ1:p2g 1.3634e-21
C_0_147 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.3918e-19
C_0_148 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 7.8459e-22
C_0_149 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 7.6360e-22
C_0_150 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 7.6349e-22
C_0_151 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:SDexcludeXG242UTiSiXG271X1 5.9592e-22
C_0_152 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:SDexcludeXG246UTiSiXG272X1 2.7843e-22
C_0_153 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:SiGeBXG261UTiSiXG271X1 2.1291e-23
C_0_154 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:SiGeBXG262UTiSiXG271X1 1.5559e-25
C_0_155 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:SiGeBXG265UTiSiXG271X1 1.4875e-25
C_0_156 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:SiliconNXG276UTiSiXG272X1 1.0391e-23
C_0_157 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:n1g 8.1187e-22
C_0_158 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:n3d 2.8874e-22
C_0_159 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:n4s 2.8874e-22
C_0_160 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:p1g 5.4726e-22
C_0_161 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 iQ2:p2s 6.1692e-22
C_0_162 BL:LM00Cobalt2XG481UTiSiXG473X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 9.8429e-22
C_0_163 BL:LM00Cobalt2XG481UTiSiXG473X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 2.0039e-23
C_0_164 BL:LM00Cobalt2XG481UTiSiXG473X1 BLB:SiliconNXG67UTiSiXG68X1 1.3686e-22
C_0_165 BL:LM00Cobalt2XG481UTiSiXG473X1 BLB:n3s 8.6857e-22
C_0_166 BL:LM00Cobalt2XG481UTiSiXG473X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.1964e-18
C_0_167 BL:LM00Cobalt2XG481UTiSiXG473X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 3.0374e-19
C_0_168 BL:LM00Cobalt2XG481UTiSiXG473X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 7.7683e-22
C_0_169 BL:LM00Cobalt2XG481UTiSiXG473X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 1.3994e-24
C_0_170 BL:LM00Cobalt2XG481UTiSiXG473X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 1.4740e-20
C_0_171 BL:LM00Cobalt2XG481UTiSiXG473X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 1.4657e-19
C_0_172 BL:LM00Cobalt2XG481UTiSiXG473X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 2.1480e-21
C_0_173 BL:LM00Cobalt2XG481UTiSiXG473X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 5.8694e-25
C_0_174 BL:LM00Cobalt2XG481UTiSiXG473X1 WL:n2g 8.0251e-20
C_0_175 BL:LM00Cobalt2XG481UTiSiXG473X1 WL:n3g 2.9057e-22
C_0_176 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 4.8621e-19
C_0_177 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 6.9775e-20
C_0_178 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 6.9537e-20
C_0_179 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 6.9519e-20
C_0_180 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:SDexcludeXG241UTiSiXG270X1 9.7799e-22
C_0_181 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:SDexcludeXG245UTiSiXG269X1 6.6377e-22
C_0_182 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:SiGeBXG256UTiSiXG270X1 2.6190e-22
C_0_183 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:SiGeBXG257UTiSiXG270X1 2.7817e-24
C_0_184 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:SiGeBXG260UTiSiXG270X1 2.7637e-24
C_0_185 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:SiGeBXG286UTiSiXG270X1 2.8174e-24
C_0_186 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:SiGeBXG290UTiSiXG270X1 2.7647e-24
C_0_187 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:SiliconNXG274UTiSiXG269X1 1.8706e-22
C_0_188 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:n1d 8.0952e-22
C_0_189 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:n2s 8.0952e-22
C_0_190 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:n4g 4.2492e-22
C_0_191 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:p1d 1.2344e-21
C_0_192 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ1:p2g 1.3149e-21
C_0_193 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 3.5547e-21
C_0_194 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.7293e-22
C_0_195 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.5767e-22
C_0_196 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.5765e-22
C_0_197 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:SDexcludeXG242UTiSiXG271X1 5.7630e-22
C_0_198 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:SDexcludeXG246UTiSiXG272X1 2.6923e-22
C_0_199 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:SiGeBXG261UTiSiXG271X1 1.5368e-23
C_0_200 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:SiGeBXG262UTiSiXG271X1 6.2964e-26
C_0_201 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:SiGeBXG265UTiSiXG271X1 5.6121e-26
C_0_202 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:SiliconNXG276UTiSiXG272X1 9.9424e-24
C_0_203 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:n1g 4.6274e-22
C_0_204 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:n3d 2.7910e-22
C_0_205 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:n4s 2.7910e-22
C_0_206 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:p1g 3.8486e-22
C_0_207 BL:LM00Cobalt2XG481UTiSiXG473X1 iQ2:p2s 5.9156e-22
C_0_208 BL:SiliconNXG468UTiSiXG473X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 3.3855e-22
C_0_209 BL:SiliconNXG468UTiSiXG473X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 1.3878e-22
C_0_210 BL:SiliconNXG468UTiSiXG473X1 BLB:SiliconNXG67UTiSiXG68X1 9.4481e-22
C_0_211 BL:SiliconNXG468UTiSiXG473X1 BLB:n3s 5.9521e-21
C_0_212 BL:SiliconNXG468UTiSiXG473X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.7573e-18
C_0_213 BL:SiliconNXG468UTiSiXG473X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 4.1808e-20
C_0_214 BL:SiliconNXG468UTiSiXG473X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 5.2021e-21
C_0_215 BL:SiliconNXG468UTiSiXG473X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 7.7376e-24
C_0_216 BL:SiliconNXG468UTiSiXG473X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 4.5863e-22
C_0_217 BL:SiliconNXG468UTiSiXG473X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 4.6426e-21
C_0_218 BL:SiliconNXG468UTiSiXG473X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 8.6488e-23
C_0_219 BL:SiliconNXG468UTiSiXG473X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 2.1819e-24
C_0_220 BL:SiliconNXG468UTiSiXG473X1 WL:n2g 1.8561e-21
C_0_221 BL:SiliconNXG468UTiSiXG473X1 WL:n3g 1.2922e-23
C_0_222 BL:SiliconNXG468UTiSiXG473X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 3.0214e-19
C_0_223 BL:SiliconNXG468UTiSiXG473X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 4.0702e-21
C_0_224 BL:SiliconNXG468UTiSiXG473X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 3.5157e-21
C_0_225 BL:SiliconNXG468UTiSiXG473X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 3.5081e-21
C_0_226 BL:SiliconNXG468UTiSiXG473X1 iQ1:SDexcludeXG241UTiSiXG270X1 6.2490e-21
C_0_227 BL:SiliconNXG468UTiSiXG473X1 iQ1:SDexcludeXG245UTiSiXG269X1 5.5895e-21
C_0_228 BL:SiliconNXG468UTiSiXG473X1 iQ1:SiGeBXG256UTiSiXG270X1 5.6597e-22
C_0_229 BL:SiliconNXG468UTiSiXG473X1 iQ1:SiGeBXG257UTiSiXG270X1 1.9209e-24
C_0_230 BL:SiliconNXG468UTiSiXG473X1 iQ1:SiGeBXG260UTiSiXG270X1 1.8994e-24
C_0_231 BL:SiliconNXG468UTiSiXG473X1 iQ1:SiGeBXG286UTiSiXG270X1 2.0114e-24
C_0_232 BL:SiliconNXG468UTiSiXG473X1 iQ1:SiGeBXG290UTiSiXG270X1 1.8997e-24
C_0_233 BL:SiliconNXG468UTiSiXG473X1 iQ1:SiliconNXG274UTiSiXG269X1 4.6513e-22
C_0_234 BL:SiliconNXG468UTiSiXG473X1 iQ1:n1d 6.0355e-21
C_0_235 BL:SiliconNXG468UTiSiXG473X1 iQ1:n2s 6.0355e-21
C_0_236 BL:SiliconNXG468UTiSiXG473X1 iQ1:n4g 1.7235e-23
C_0_237 BL:SiliconNXG468UTiSiXG473X1 iQ1:p1d 6.8112e-21
C_0_238 BL:SiliconNXG468UTiSiXG473X1 iQ1:p2g 4.3976e-23
C_0_239 BL:SiliconNXG468UTiSiXG473X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.9638e-20
C_0_240 BL:SiliconNXG468UTiSiXG473X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.1280e-22
C_0_241 BL:SiliconNXG468UTiSiXG473X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.0230e-23
C_0_242 BL:SiliconNXG468UTiSiXG473X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 3.0385e-23
C_0_243 BL:SiliconNXG468UTiSiXG473X1 iQ2:SDexcludeXG242UTiSiXG271X1 3.4948e-21
C_0_244 BL:SiliconNXG468UTiSiXG473X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.7192e-21
C_0_245 BL:SiliconNXG468UTiSiXG473X1 iQ2:SiGeBXG261UTiSiXG271X1 8.2595e-23
C_0_246 BL:SiliconNXG468UTiSiXG473X1 iQ2:SiGeBXG262UTiSiXG271X1 4.8883e-26
C_0_247 BL:SiliconNXG468UTiSiXG473X1 iQ2:SiGeBXG265UTiSiXG271X1 1.3149e-26
C_0_248 BL:SiliconNXG468UTiSiXG473X1 iQ2:SiliconNXG276UTiSiXG272X1 6.2306e-23
C_0_249 BL:SiliconNXG468UTiSiXG473X1 iQ2:n1g 2.1697e-23
C_0_250 BL:SiliconNXG468UTiSiXG473X1 iQ2:n3d 1.7812e-21
C_0_251 BL:SiliconNXG468UTiSiXG473X1 iQ2:n4s 1.7812e-21
C_0_252 BL:SiliconNXG468UTiSiXG473X1 iQ2:p1g 1.7327e-23
C_0_253 BL:SiliconNXG468UTiSiXG473X1 iQ2:p2s 3.5773e-21
C_0_254 BL:n2d BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.1569e-21
C_0_255 BL:n2d BLB:LM00Cobalt2XG64UTiSiXG68X1 8.8180e-22
C_0_256 BL:n2d BLB:SiliconNXG67UTiSiXG68X1 5.9573e-21
C_0_257 BL:n2d BLB:n3s 3.7335e-20
C_0_258 BL:n2d WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 3.7148e-18
C_0_259 BL:n2d WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 4.5048e-20
C_0_260 BL:n2d WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 3.2288e-20
C_0_261 BL:n2d WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 4.8524e-23
C_0_262 BL:n2d WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 4.8550e-22
C_0_263 BL:n2d WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 4.9070e-21
C_0_264 BL:n2d WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 9.3469e-23
C_0_265 BL:n2d WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 1.3562e-23
C_0_266 BL:n2d iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 5.9651e-19
C_0_267 BL:n2d iQ1:LM00Cobalt2XG275USiGeBXG256X1 5.8063e-21
C_0_268 BL:n2d iQ1:LM00Cobalt2XG275UTiSiXG269X1 4.1468e-21
C_0_269 BL:n2d iQ1:LM00Cobalt2XG275UTiSiXG270X1 4.1353e-21
C_0_270 BL:n2d iQ1:SDexcludeXG241UTiSiXG270X1 3.9205e-20
C_0_271 BL:n2d iQ1:SDexcludeXG245UTiSiXG269X1 8.1577e-20
C_0_272 BL:n2d iQ1:SiGeBXG256UTiSiXG270X1 1.6756e-21
C_0_273 BL:n2d iQ1:SiGeBXG257UTiSiXG270X1 2.2778e-24
C_0_274 BL:n2d iQ1:SiGeBXG260UTiSiXG270X1 2.2544e-24
C_0_275 BL:n2d iQ1:SiGeBXG286UTiSiXG270X1 2.5096e-24
C_0_276 BL:n2d iQ1:SiGeBXG290UTiSiXG270X1 2.2527e-24
C_0_277 BL:n2d iQ1:SiliconNXG274UTiSiXG269X1 2.1082e-21
C_0_278 BL:n2d iQ1:n1d 8.3657e-20
C_0_279 BL:n2d iQ1:n2s 8.3657e-20
C_0_280 BL:n2d iQ1:p1d 4.0876e-20
C_0_281 BL:n2d iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.3666e-19
C_0_282 BL:n2d iQ2:LM00Cobalt2XG118USiGeBXG261X1 5.5981e-22
C_0_283 BL:n2d iQ2:LM00Cobalt2XG118UTiSiXG271X1 6.8362e-23
C_0_284 BL:n2d iQ2:LM00Cobalt2XG118UTiSiXG272X1 6.9308e-23
C_0_285 BL:n2d iQ2:SDexcludeXG242UTiSiXG271X1 2.0614e-20
C_0_286 BL:n2d iQ2:SDexcludeXG246UTiSiXG272X1 1.0447e-20
C_0_287 BL:n2d iQ2:SiGeBXG261UTiSiXG271X1 4.9153e-22
C_0_288 BL:n2d iQ2:SiGeBXG262UTiSiXG271X1 1.7482e-25
C_0_289 BL:n2d iQ2:SiGeBXG265UTiSiXG271X1 4.1911e-26
C_0_290 BL:n2d iQ2:SiliconNXG276UTiSiXG272X1 3.7674e-22
C_0_291 BL:n2d iQ2:n3d 1.0822e-20
C_0_292 BL:n2d iQ2:n4s 1.0822e-20
C_0_293 BL:n2d iQ2:p2s 2.1105e-20
R_0_0 BLD BLU 2.3455e+01
R_0_1 BLD BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 2.2364e+01
R_0_2 BLU BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 6.1588e+02
R_0_3 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 BL:LM00Cobalt2XG481UTiSiXG473X1 1.2276e+02
R_0_4 BL:LM00Cobalt2XG481UTiSiXG473X1 BL:SiliconNXG468UTiSiXG473X1 4.5683e+02
R_0_5 BL:SiliconNXG468UTiSiXG473X1 BL:n2d 4.1804e+01

*|NET BLB 4.3463e-05PF
C_1_0 BLBD WLL 2.9219e-19
C_1_1 BLBD WLR 2.9219e-19
C_1_2 BLBD WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 2.3814e-22
C_1_3 BLBD WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 3.6421e-23
C_1_4 BLBD WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 1.3005e-19
C_1_5 BLBD WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 7.2082e-19
C_1_6 BLBD WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 2.9221e-19
C_1_7 BLBD WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 3.5975e-23
C_1_8 BLBD WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 4.0095e-19
C_1_9 BLBD WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 7.6950e-19
C_1_10 BLBD WL:n2g 3.5183e-23
C_1_11 BLBD WL:n3g 4.9623e-22
C_1_12 BLBD iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.4546e-19
C_1_13 BLBD iQ1:LM00Cobalt2XG275USiGeBXG256X1 6.3289e-22
C_1_14 BLBD iQ1:LM00Cobalt2XG275UTiSiXG269X1 6.2639e-22
C_1_15 BLBD iQ1:LM00Cobalt2XG275UTiSiXG270X1 6.2647e-22
C_1_16 BLBD iQ1:SDexcludeXG241UTiSiXG270X1 4.3581e-23
C_1_17 BLBD iQ1:SDexcludeXG245UTiSiXG269X1 2.0597e-23
C_1_18 BLBD iQ1:SiGeBXG256UTiSiXG270X1 6.5967e-24
C_1_19 BLBD iQ1:SiGeBXG257UTiSiXG270X1 8.8570e-26
C_1_20 BLBD iQ1:SiGeBXG260UTiSiXG270X1 8.7693e-26
C_1_21 BLBD iQ1:SiGeBXG286UTiSiXG270X1 8.8515e-26
C_1_22 BLBD iQ1:SiGeBXG290UTiSiXG270X1 8.7559e-26
C_1_23 BLBD iQ1:SiliconNXG274UTiSiXG269X1 9.0324e-25
C_1_24 BLBD iQ1:n1d 2.1481e-23
C_1_25 BLBD iQ1:n2s 2.1481e-23
C_1_26 BLBD iQ1:n4g 4.6623e-22
C_1_27 BLBD iQ1:p1d 5.0003e-23
C_1_28 BLBD iQ1:p2g 2.1567e-22
C_1_29 BLBD iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.2061e-19
C_1_30 BLBD iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.9108e-19
C_1_31 BLBD iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.9107e-19
C_1_32 BLBD iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.9109e-19
C_1_33 BLBD iQ2:SDexcludeXG242UTiSiXG271X1 6.7114e-23
C_1_34 BLBD iQ2:SDexcludeXG246UTiSiXG272X1 8.0358e-23
C_1_35 BLBD iQ2:SiGeBXG261UTiSiXG271X1 1.6849e-23
C_1_36 BLBD iQ2:SiGeBXG262UTiSiXG271X1 6.8327e-25
C_1_37 BLBD iQ2:SiGeBXG265UTiSiXG271X1 6.8063e-25
C_1_38 BLBD iQ2:SiliconNXG276UTiSiXG272X1 8.3331e-23
C_1_39 BLBD iQ2:n1g 3.0667e-23
C_1_40 BLBD iQ2:n3d 1.0723e-22
C_1_41 BLBD iQ2:n4s 1.0723e-22
C_1_42 BLBD iQ2:p1g 8.7647e-23
C_1_43 BLBD iQ2:p2s 8.2602e-23
C_1_44 BLBU WLL 2.9219e-19
C_1_45 BLBU WLR 2.9219e-19
C_1_46 BLBU WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 2.3814e-22
C_1_47 BLBU WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 3.6421e-23
C_1_48 BLBU WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 1.3005e-19
C_1_49 BLBU WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 7.2082e-19
C_1_50 BLBU WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 2.9221e-19
C_1_51 BLBU WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 3.5975e-23
C_1_52 BLBU WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 4.0095e-19
C_1_53 BLBU WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 7.6950e-19
C_1_54 BLBU WL:n2g 3.5183e-23
C_1_55 BLBU WL:n3g 4.9623e-22
C_1_56 BLBU iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.4546e-19
C_1_57 BLBU iQ1:LM00Cobalt2XG275USiGeBXG256X1 6.3289e-22
C_1_58 BLBU iQ1:LM00Cobalt2XG275UTiSiXG269X1 6.2639e-22
C_1_59 BLBU iQ1:LM00Cobalt2XG275UTiSiXG270X1 6.2647e-22
C_1_60 BLBU iQ1:SDexcludeXG241UTiSiXG270X1 4.3581e-23
C_1_61 BLBU iQ1:SDexcludeXG245UTiSiXG269X1 2.0597e-23
C_1_62 BLBU iQ1:SiGeBXG256UTiSiXG270X1 6.5967e-24
C_1_63 BLBU iQ1:SiGeBXG257UTiSiXG270X1 8.8570e-26
C_1_64 BLBU iQ1:SiGeBXG260UTiSiXG270X1 8.7693e-26
C_1_65 BLBU iQ1:SiGeBXG286UTiSiXG270X1 8.8515e-26
C_1_66 BLBU iQ1:SiGeBXG290UTiSiXG270X1 8.7559e-26
C_1_67 BLBU iQ1:SiliconNXG274UTiSiXG269X1 9.0324e-25
C_1_68 BLBU iQ1:n1d 2.1481e-23
C_1_69 BLBU iQ1:n2s 2.1481e-23
C_1_70 BLBU iQ1:n4g 4.6623e-22
C_1_71 BLBU iQ1:p1d 5.0003e-23
C_1_72 BLBU iQ1:p2g 2.1567e-22
C_1_73 BLBU iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.2061e-19
C_1_74 BLBU iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.9108e-19
C_1_75 BLBU iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.9107e-19
C_1_76 BLBU iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.9109e-19
C_1_77 BLBU iQ2:SDexcludeXG242UTiSiXG271X1 6.7114e-23
C_1_78 BLBU iQ2:SDexcludeXG246UTiSiXG272X1 8.0358e-23
C_1_79 BLBU iQ2:SiGeBXG261UTiSiXG271X1 1.6849e-23
C_1_80 BLBU iQ2:SiGeBXG262UTiSiXG271X1 6.8327e-25
C_1_81 BLBU iQ2:SiGeBXG265UTiSiXG271X1 6.8063e-25
C_1_82 BLBU iQ2:SiliconNXG276UTiSiXG272X1 8.3331e-23
C_1_83 BLBU iQ2:n1g 3.0667e-23
C_1_84 BLBU iQ2:n3d 1.0723e-22
C_1_85 BLBU iQ2:n4s 1.0723e-22
C_1_86 BLBU iQ2:p1g 8.7647e-23
C_1_87 BLBU iQ2:p2s 8.2602e-23
C_1_88 WLL BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 2.9396e-19
C_1_89 WLL BLB:LM00Cobalt2XG64UTiSiXG68X1 1.7740e-21
C_1_90 WLL BLB:SiliconNXG67UTiSiXG68X1 7.1121e-23
C_1_91 WLL BLB:n3s 7.6855e-23
C_1_92 WLR BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 2.9396e-19
C_1_93 WLR BLB:LM00Cobalt2XG64UTiSiXG68X1 1.7740e-21
C_1_94 WLR BLB:SiliconNXG67UTiSiXG68X1 7.1121e-23
C_1_95 WLR BLB:n3s 7.6855e-23
C_1_96 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 9.7253e-22
C_1_97 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 3.7852e-23
C_1_98 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 1.4904e-18
C_1_99 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 1.0924e-18
C_1_100 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 2.9398e-19
C_1_101 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 3.6619e-23
C_1_102 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 4.0732e-19
C_1_103 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 9.7304e-19
C_1_104 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 WL:n2g 3.1886e-22
C_1_105 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 WL:n3g 9.6921e-20
C_1_106 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.4894e-19
C_1_107 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 8.0030e-22
C_1_108 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 7.7885e-22
C_1_109 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 7.7897e-22
C_1_110 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:SDexcludeXG241UTiSiXG270X1 6.0351e-22
C_1_111 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:SDexcludeXG245UTiSiXG269X1 2.8217e-22
C_1_112 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:SiGeBXG256UTiSiXG270X1 2.1609e-23
C_1_113 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:SiGeBXG257UTiSiXG270X1 1.4422e-25
C_1_114 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:SiGeBXG260UTiSiXG270X1 1.4161e-25
C_1_115 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:SiGeBXG286UTiSiXG270X1 1.5536e-25
C_1_116 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:SiGeBXG290UTiSiXG270X1 1.4119e-25
C_1_117 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:SiliconNXG274UTiSiXG269X1 1.0621e-23
C_1_118 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:n1d 2.9276e-22
C_1_119 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:n2s 2.9276e-22
C_1_120 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:n4g 9.1155e-22
C_1_121 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:p1d 6.2484e-22
C_1_122 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ1:p2g 5.8561e-22
C_1_123 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 7.2750e-19
C_1_124 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 2.6488e-19
C_1_125 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.6462e-19
C_1_126 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.6466e-19
C_1_127 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:SDexcludeXG242UTiSiXG271X1 1.0093e-21
C_1_128 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:SDexcludeXG246UTiSiXG272X1 7.1036e-22
C_1_129 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:SiGeBXG261UTiSiXG271X1 2.6358e-22
C_1_130 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:SiGeBXG262UTiSiXG271X1 4.1531e-24
C_1_131 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:SiGeBXG265UTiSiXG271X1 4.1420e-24
C_1_132 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:SiliconNXG276UTiSiXG272X1 2.3814e-22
C_1_133 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:n1g 4.4382e-22
C_1_134 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:n3d 8.5777e-22
C_1_135 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:n4s 8.5777e-22
C_1_136 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:p1g 1.3605e-21
C_1_137 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 iQ2:p2s 1.2646e-21
C_1_138 BLB:LM00Cobalt2XG64UTiSiXG68X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 7.6761e-22
C_1_139 BLB:LM00Cobalt2XG64UTiSiXG68X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 1.4804e-24
C_1_140 BLB:LM00Cobalt2XG64UTiSiXG68X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 1.3684e-18
C_1_141 BLB:LM00Cobalt2XG64UTiSiXG68X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 3.7244e-19
C_1_142 BLB:LM00Cobalt2XG64UTiSiXG68X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 1.7740e-21
C_1_143 BLB:LM00Cobalt2XG64UTiSiXG68X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 6.5673e-25
C_1_144 BLB:LM00Cobalt2XG64UTiSiXG68X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 6.3807e-21
C_1_145 BLB:LM00Cobalt2XG64UTiSiXG68X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 2.0375e-19
C_1_146 BLB:LM00Cobalt2XG64UTiSiXG68X1 WL:n2g 2.9652e-22
C_1_147 BLB:LM00Cobalt2XG64UTiSiXG68X1 WL:n3g 9.8875e-20
C_1_148 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 3.6215e-21
C_1_149 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.6906e-22
C_1_150 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.5353e-22
C_1_151 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.5357e-22
C_1_152 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:SDexcludeXG241UTiSiXG270X1 5.8440e-22
C_1_153 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:SDexcludeXG245UTiSiXG269X1 2.7319e-22
C_1_154 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:SiGeBXG256UTiSiXG270X1 1.5597e-23
C_1_155 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:SiGeBXG257UTiSiXG270X1 5.6272e-26
C_1_156 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:SiGeBXG260UTiSiXG270X1 5.4324e-26
C_1_157 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:SiGeBXG286UTiSiXG270X1 6.7846e-26
C_1_158 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:SiGeBXG290UTiSiXG270X1 5.4040e-26
C_1_159 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:SiliconNXG274UTiSiXG269X1 1.0147e-23
C_1_160 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:n1d 2.8332e-22
C_1_161 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:n2s 2.8332e-22
C_1_162 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:n4g 4.6658e-22
C_1_163 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:p1d 5.9989e-22
C_1_164 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ1:p2g 3.8690e-22
C_1_165 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 5.1208e-19
C_1_166 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 7.3925e-20
C_1_167 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 7.3682e-20
C_1_168 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 7.3696e-20
C_1_169 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:SDexcludeXG242UTiSiXG271X1 9.8267e-22
C_1_170 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:SDexcludeXG246UTiSiXG272X1 6.5955e-22
C_1_171 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:SiGeBXG261UTiSiXG271X1 2.4972e-22
C_1_172 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:SiGeBXG262UTiSiXG271X1 3.4884e-24
C_1_173 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:SiGeBXG265UTiSiXG271X1 3.4797e-24
C_1_174 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:SiliconNXG276UTiSiXG272X1 1.5698e-22
C_1_175 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:n1g 4.3018e-22
C_1_176 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:n3d 7.8214e-22
C_1_177 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:n4s 7.8214e-22
C_1_178 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:p1g 1.3164e-21
C_1_179 BLB:LM00Cobalt2XG64UTiSiXG68X1 iQ2:p2s 1.2254e-21
C_1_180 BLB:SiliconNXG67UTiSiXG68X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 5.0669e-21
C_1_181 BLB:SiliconNXG67UTiSiXG68X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 7.2079e-24
C_1_182 BLB:SiliconNXG67UTiSiXG68X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 1.7508e-18
C_1_183 BLB:SiliconNXG67UTiSiXG68X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 4.3011e-20
C_1_184 BLB:SiliconNXG67UTiSiXG68X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 7.1275e-23
C_1_185 BLB:SiliconNXG67UTiSiXG68X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 1.5936e-24
C_1_186 BLB:SiliconNXG67UTiSiXG68X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 2.0722e-22
C_1_187 BLB:SiliconNXG67UTiSiXG68X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 6.6709e-21
C_1_188 BLB:SiliconNXG67UTiSiXG68X1 WL:n2g 1.2842e-23
C_1_189 BLB:SiliconNXG67UTiSiXG68X1 WL:n3g 2.4503e-21
C_1_190 BLB:SiliconNXG67UTiSiXG68X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.9616e-20
C_1_191 BLB:SiliconNXG67UTiSiXG68X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.1137e-22
C_1_192 BLB:SiliconNXG67UTiSiXG68X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 2.8534e-23
C_1_193 BLB:SiliconNXG67UTiSiXG68X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 2.8505e-23
C_1_194 BLB:SiliconNXG67UTiSiXG68X1 iQ1:SDexcludeXG241UTiSiXG270X1 3.4890e-21
C_1_195 BLB:SiliconNXG67UTiSiXG68X1 iQ1:SDexcludeXG245UTiSiXG269X1 1.7190e-21
C_1_196 BLB:SiliconNXG67UTiSiXG68X1 iQ1:SiGeBXG256UTiSiXG270X1 8.2896e-23
C_1_197 BLB:SiliconNXG67UTiSiXG68X1 iQ1:SiGeBXG257UTiSiXG270X1 4.6797e-26
C_1_198 BLB:SiliconNXG67UTiSiXG68X1 iQ1:SiGeBXG260UTiSiXG270X1 1.6558e-26
C_1_199 BLB:SiliconNXG67UTiSiXG68X1 iQ1:SiGeBXG286UTiSiXG270X1 1.0152e-25
C_1_200 BLB:SiliconNXG67UTiSiXG68X1 iQ1:SiGeBXG290UTiSiXG270X1 1.6549e-26
C_1_201 BLB:SiliconNXG67UTiSiXG68X1 iQ1:SiliconNXG274UTiSiXG269X1 6.2887e-23
C_1_202 BLB:SiliconNXG67UTiSiXG68X1 iQ1:n1d 1.7818e-21
C_1_203 BLB:SiliconNXG67UTiSiXG68X1 iQ1:n2s 1.7818e-21
C_1_204 BLB:SiliconNXG67UTiSiXG68X1 iQ1:n4g 2.1270e-23
C_1_205 BLB:SiliconNXG67UTiSiXG68X1 iQ1:p1d 3.5718e-21
C_1_206 BLB:SiliconNXG67UTiSiXG68X1 iQ1:p2g 1.6962e-23
C_1_207 BLB:SiliconNXG67UTiSiXG68X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.8720e-19
C_1_208 BLB:SiliconNXG67UTiSiXG68X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 3.5045e-21
C_1_209 BLB:SiliconNXG67UTiSiXG68X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.0385e-21
C_1_210 BLB:SiliconNXG67UTiSiXG68X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 3.0422e-21
C_1_211 BLB:SiliconNXG67UTiSiXG68X1 iQ2:SDexcludeXG242UTiSiXG271X1 6.1669e-21
C_1_212 BLB:SiliconNXG67UTiSiXG68X1 iQ2:SDexcludeXG246UTiSiXG272X1 5.5293e-21
C_1_213 BLB:SiliconNXG67UTiSiXG68X1 iQ2:SiGeBXG261UTiSiXG271X1 4.6996e-22
C_1_214 BLB:SiliconNXG67UTiSiXG68X1 iQ2:SiGeBXG262UTiSiXG271X1 1.9797e-24
C_1_215 BLB:SiliconNXG67UTiSiXG68X1 iQ2:SiGeBXG265UTiSiXG271X1 1.9558e-24
C_1_216 BLB:SiliconNXG67UTiSiXG68X1 iQ2:SiliconNXG276UTiSiXG272X1 3.7101e-22
C_1_217 BLB:SiliconNXG67UTiSiXG68X1 iQ2:n1g 1.7030e-23
C_1_218 BLB:SiliconNXG67UTiSiXG68X1 iQ2:n3d 5.8890e-21
C_1_219 BLB:SiliconNXG67UTiSiXG68X1 iQ2:n4s 5.8890e-21
C_1_220 BLB:SiliconNXG67UTiSiXG68X1 iQ2:p1g 4.3558e-23
C_1_221 BLB:SiliconNXG67UTiSiXG68X1 iQ2:p2s 6.6330e-21
C_1_222 BLB:n3s WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 3.1424e-20
C_1_223 BLB:n3s WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 4.4891e-23
C_1_224 BLB:n3s WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 3.7210e-18
C_1_225 BLB:n3s WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 4.6116e-20
C_1_226 BLB:n3s WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 7.7776e-23
C_1_227 BLB:n3s WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 9.5189e-24
C_1_228 BLB:n3s WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 2.2034e-22
C_1_229 BLB:n3s WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 7.0346e-21
C_1_230 BLB:n3s iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.3674e-19
C_1_231 BLB:n3s iQ1:LM00Cobalt2XG275USiGeBXG256X1 5.6106e-22
C_1_232 BLB:n3s iQ1:LM00Cobalt2XG275UTiSiXG269X1 6.8264e-23
C_1_233 BLB:n3s iQ1:LM00Cobalt2XG275UTiSiXG270X1 6.8064e-23
C_1_234 BLB:n3s iQ1:SDexcludeXG241UTiSiXG270X1 2.0563e-20
C_1_235 BLB:n3s iQ1:SDexcludeXG245UTiSiXG269X1 1.0436e-20
C_1_236 BLB:n3s iQ1:SiGeBXG256UTiSiXG270X1 4.9313e-22
C_1_237 BLB:n3s iQ1:SiGeBXG257UTiSiXG270X1 1.7248e-25
C_1_238 BLB:n3s iQ1:SiGeBXG260UTiSiXG270X1 6.6165e-26
C_1_239 BLB:n3s iQ1:SiGeBXG286UTiSiXG270X1 5.3468e-25
C_1_240 BLB:n3s iQ1:SiGeBXG290UTiSiXG270X1 6.5044e-26
C_1_241 BLB:n3s iQ1:SiliconNXG274UTiSiXG269X1 3.8023e-22
C_1_242 BLB:n3s iQ1:n1d 1.0816e-20
C_1_243 BLB:n3s iQ1:n2s 1.0816e-20
C_1_244 BLB:n3s iQ1:p1d 2.1056e-20
C_1_245 BLB:n3s iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 5.7203e-19
C_1_246 BLB:n3s iQ2:LM00Cobalt2XG118USiGeBXG261X1 5.0872e-21
C_1_247 BLB:n3s iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.5731e-21
C_1_248 BLB:n3s iQ2:LM00Cobalt2XG118UTiSiXG272X1 3.5822e-21
C_1_249 BLB:n3s iQ2:SDexcludeXG242UTiSiXG271X1 3.8836e-20
C_1_250 BLB:n3s iQ2:SDexcludeXG246UTiSiXG272X1 8.1752e-20
C_1_251 BLB:n3s iQ2:SiGeBXG261UTiSiXG271X1 1.5188e-21
C_1_252 BLB:n3s iQ2:SiGeBXG262UTiSiXG271X1 2.3575e-24
C_1_253 BLB:n3s iQ2:SiGeBXG265UTiSiXG271X1 2.3299e-24
C_1_254 BLB:n3s iQ2:SiliconNXG276UTiSiXG272X1 1.9518e-21
C_1_255 BLB:n3s iQ2:n3d 8.3681e-20
C_1_256 BLB:n3s iQ2:n4s 8.3681e-20
C_1_257 BLB:n3s iQ2:p2s 4.0350e-20
R_1_0 BLBD BLBU 2.3384e+01
R_1_1 BLBD BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 5.2208e+02
R_1_2 BLBU BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.9977e+01
R_1_3 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 9.9701e+01
R_1_4 BLB:LM00Cobalt2XG64UTiSiXG68X1 BLB:SiliconNXG67UTiSiXG68X1 3.9649e+02
R_1_5 BLB:SiliconNXG67UTiSiXG68X1 BLB:n3s 4.1701e+01

*|NET VDD 6.6897e-05PF
C_2_0 BLBD VDD 1.0343e-18
C_2_1 BLBD VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 1.1517e-18
C_2_2 BLBD VDD:LM00Cobalt2XG483UTiSiXG476X1 1.1768e-19
C_2_3 BLBD VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 1.0455e-18
C_2_4 BLBD VDD:LM00Cobalt2XG48UTiSiXG50X1 1.1314e-20
C_2_5 BLBD VDD:SiGeBXG465UTiSiXG476X1 2.9742e-21
C_2_6 BLBD VDD:SiGeBXG49UTiSiXG50X1 1.3678e-21
C_2_7 BLBD VDD:p1s 1.6486e-21
C_2_8 BLBD VDD:p2d 3.1514e-21
C_2_9 BLBU VDD 1.0343e-18
C_2_10 BLBU VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 1.1517e-18
C_2_11 BLBU VDD:LM00Cobalt2XG483UTiSiXG476X1 1.1768e-19
C_2_12 BLBU VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 1.0455e-18
C_2_13 BLBU VDD:LM00Cobalt2XG48UTiSiXG50X1 1.1314e-20
C_2_14 BLBU VDD:SiGeBXG465UTiSiXG476X1 2.9742e-21
C_2_15 BLBU VDD:SiGeBXG49UTiSiXG50X1 1.3678e-21
C_2_16 BLBU VDD:p1s 1.6486e-21
C_2_17 BLBU VDD:p2d 3.1514e-21
C_2_18 BLD VDD 1.0321e-18
C_2_19 BLD VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 1.0433e-18
C_2_20 BLD VDD:LM00Cobalt2XG483UTiSiXG476X1 1.1237e-20
C_2_21 BLD VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 1.1527e-18
C_2_22 BLD VDD:LM00Cobalt2XG48UTiSiXG50X1 1.2088e-19
C_2_23 BLD VDD:SiGeBXG465UTiSiXG476X1 1.3982e-21
C_2_24 BLD VDD:SiGeBXG49UTiSiXG50X1 2.9581e-21
C_2_25 BLD VDD:p1s 3.1188e-21
C_2_26 BLD VDD:p2d 1.6885e-21
C_2_27 BLU VDD 1.0321e-18
C_2_28 BLU VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 1.0433e-18
C_2_29 BLU VDD:LM00Cobalt2XG483UTiSiXG476X1 1.1237e-20
C_2_30 BLU VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 1.1527e-18
C_2_31 BLU VDD:LM00Cobalt2XG48UTiSiXG50X1 1.2088e-19
C_2_32 BLU VDD:SiGeBXG465UTiSiXG476X1 1.3982e-21
C_2_33 BLU VDD:SiGeBXG49UTiSiXG50X1 2.9581e-21
C_2_34 BLU VDD:p1s 3.1188e-21
C_2_35 BLU VDD:p2d 1.6885e-21
C_2_36 VDD VSS 1.1173e-18
C_2_37 VDD VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 2.5765e-20
C_2_38 VDD VSS:LM00Cobalt2XG17UTiSiXG32X1 2.0927e-20
C_2_39 VDD VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 2.5747e-20
C_2_40 VDD VSS:LM00Cobalt2XG485UTiSiXG478X1 2.0859e-20
C_2_41 VDD VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 1.2760e-20
C_2_42 VDD VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 6.9627e-21
C_2_43 VDD VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 1.3652e-20
C_2_44 VDD VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 6.9685e-21
C_2_45 VDD VSS:SiliconNXG31UTiSiXG32X1 1.7811e-21
C_2_46 VDD VSS:SiliconNXG469UTiSiXG478X1 1.7850e-21
C_2_47 VDD VSS:n1s 2.1407e-21
C_2_48 VDD VSS:n4d 2.1484e-21
C_2_49 VDD WLL 5.2503e-19
C_2_50 VDD WLR 5.2503e-19
C_2_51 VDD BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.1088e-18
C_2_52 VDD BLB:LM00Cobalt2XG64UTiSiXG68X1 7.4753e-20
C_2_53 VDD BLB:SiliconNXG67UTiSiXG68X1 5.7331e-21
C_2_54 VDD BLB:n3s 6.6877e-21
C_2_55 VDD BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 1.1051e-18
C_2_56 VDD BL:LM00Cobalt2XG481UTiSiXG473X1 7.3293e-20
C_2_57 VDD BL:SiliconNXG468UTiSiXG473X1 5.8545e-21
C_2_58 VDD BL:n2d 6.8332e-21
C_2_59 VDD WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.3049e-20
C_2_60 VDD WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 3.5400e-21
C_2_61 VDD WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 1.2575e-20
C_2_62 VDD WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 4.9683e-21
C_2_63 VDD WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 5.2687e-19
C_2_64 VDD WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 4.1145e-21
C_2_65 VDD WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 5.2639e-19
C_2_66 VDD WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 5.1901e-21
C_2_67 VDD WL:n2g 3.7303e-22
C_2_68 VDD WL:n3g 3.3843e-22
C_2_69 VDD iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 4.0369e-19
C_2_70 VDD iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.7884e-19
C_2_71 VDD iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.7846e-19
C_2_72 VDD iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.7847e-19
C_2_73 VDD iQ1:SDexcludeXG241UTiSiXG270X1 2.1743e-22
C_2_74 VDD iQ1:SDexcludeXG245UTiSiXG269X1 8.4195e-23
C_2_75 VDD iQ1:SiGeBXG256UTiSiXG270X1 3.9249e-22
C_2_76 VDD iQ1:SiGeBXG257UTiSiXG270X1 8.1399e-24
C_2_77 VDD iQ1:SiGeBXG260UTiSiXG270X1 8.1629e-24
C_2_78 VDD iQ1:SiGeBXG286UTiSiXG270X1 8.2370e-24
C_2_79 VDD iQ1:SiGeBXG290UTiSiXG270X1 8.1159e-24
C_2_80 VDD iQ1:SiliconNXG274UTiSiXG269X1 8.8741e-24
C_2_81 VDD iQ1:n1d 9.0844e-23
C_2_82 VDD iQ1:n2s 9.0844e-23
C_2_83 VDD iQ1:n4g 1.5214e-22
C_2_84 VDD iQ1:p1d 5.9369e-22
C_2_85 VDD iQ1:p2g 7.6257e-22
C_2_86 VDD iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 3.9442e-19
C_2_87 VDD iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.7860e-19
C_2_88 VDD iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.7823e-19
C_2_89 VDD iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.7822e-19
C_2_90 VDD iQ2:SDexcludeXG242UTiSiXG271X1 2.1699e-22
C_2_91 VDD iQ2:SDexcludeXG246UTiSiXG272X1 8.3460e-23
C_2_92 VDD iQ2:SiGeBXG261UTiSiXG271X1 3.9671e-22
C_2_93 VDD iQ2:SiGeBXG262UTiSiXG271X1 8.5441e-24
C_2_94 VDD iQ2:SiGeBXG265UTiSiXG271X1 8.5090e-24
C_2_95 VDD iQ2:SiliconNXG276UTiSiXG272X1 7.6390e-24
C_2_96 VDD iQ2:n1g 1.4464e-22
C_2_97 VDD iQ2:n3d 8.9057e-23
C_2_98 VDD iQ2:n4s 8.9057e-23
C_2_99 VDD iQ2:p1g 6.6847e-22
C_2_100 VDD iQ2:p2s 5.9668e-22
C_2_101 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS 1.1306e-18
C_2_102 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 2.5784e-20
C_2_103 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS:LM00Cobalt2XG17UTiSiXG32X1 2.0947e-20
C_2_104 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 4.0445e-19
C_2_105 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS:LM00Cobalt2XG485UTiSiXG478X1 3.9890e-19
C_2_106 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 1.2761e-20
C_2_107 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 6.9631e-21
C_2_108 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 1.5292e-20
C_2_109 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 1.3271e-20
C_2_110 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS:SiliconNXG31UTiSiXG32X1 1.9099e-21
C_2_111 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS:SiliconNXG469UTiSiXG478X1 7.5148e-20
C_2_112 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS:n1s 3.0837e-21
C_2_113 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VSS:n4d 8.0593e-20
C_2_114 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 WLL 5.2562e-19
C_2_115 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 WLR 5.2562e-19
C_2_116 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.2262e-18
C_2_117 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 7.4791e-20
C_2_118 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 BLB:SiliconNXG67UTiSiXG68X1 5.8886e-21
C_2_119 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 BLB:n3s 7.7027e-21
C_2_120 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 1.1619e-18
C_2_121 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 BL:LM00Cobalt2XG481UTiSiXG473X1 1.1944e-19
C_2_122 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 BL:SiliconNXG468UTiSiXG473X1 2.0966e-20
C_2_123 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 BL:n2d 2.7439e-20
C_2_124 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 2.7465e-20
C_2_125 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 4.4531e-21
C_2_126 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 1.3643e-20
C_2_127 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 5.1199e-21
C_2_128 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 5.2754e-19
C_2_129 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 4.5767e-21
C_2_130 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 5.2697e-19
C_2_131 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 5.3137e-21
C_2_132 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 WL:n2g 1.8638e-21
C_2_133 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 WL:n3g 7.1154e-22
C_2_134 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 2.3419e-18
C_2_135 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 2.1072e-19
C_2_136 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 2.1024e-19
C_2_137 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 2.1025e-19
C_2_138 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:SDexcludeXG241UTiSiXG270X1 1.0403e-21
C_2_139 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:SDexcludeXG245UTiSiXG269X1 4.8129e-22
C_2_140 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:SiGeBXG256UTiSiXG270X1 4.8900e-22
C_2_141 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:SiGeBXG257UTiSiXG270X1 9.0724e-24
C_2_142 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:SiGeBXG260UTiSiXG270X1 9.0735e-24
C_2_143 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:SiGeBXG286UTiSiXG270X1 9.2153e-24
C_2_144 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:SiGeBXG290UTiSiXG270X1 9.0236e-24
C_2_145 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:SiliconNXG274UTiSiXG269X1 3.5272e-23
C_2_146 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:n1d 5.1294e-22
C_2_147 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:n2s 5.1294e-22
C_2_148 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:n4g 3.7291e-21
C_2_149 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:p1d 1.5112e-21
C_2_150 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ1:p2g 1.0509e-19
C_2_151 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 4.2535e-19
C_2_152 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 2.0484e-19
C_2_153 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.0437e-19
C_2_154 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.0436e-19
C_2_155 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:SDexcludeXG242UTiSiXG271X1 1.0162e-21
C_2_156 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:SDexcludeXG246UTiSiXG272X1 5.1631e-22
C_2_157 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:SiGeBXG261UTiSiXG271X1 4.9276e-22
C_2_158 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:SiGeBXG262UTiSiXG271X1 1.1553e-23
C_2_159 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:SiGeBXG265UTiSiXG271X1 1.1503e-23
C_2_160 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:SiliconNXG276UTiSiXG272X1 3.0700e-23
C_2_161 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:n1g 5.0165e-22
C_2_162 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:n3d 5.4170e-22
C_2_163 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:n4s 5.4170e-22
C_2_164 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:p1g 1.0334e-21
C_2_165 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 iQ2:p2s 1.4859e-21
C_2_166 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS 1.3438e-20
C_2_167 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 2.0064e-23
C_2_168 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS:LM00Cobalt2XG17UTiSiXG32X1 2.0902e-23
C_2_169 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 3.8226e-19
C_2_170 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS:LM00Cobalt2XG485UTiSiXG478X1 3.8173e-19
C_2_171 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 2.7658e-25
C_2_172 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 4.0560e-25
C_2_173 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 1.6495e-21
C_2_174 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 6.3523e-21
C_2_175 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS:SiliconNXG31UTiSiXG32X1 1.3657e-22
C_2_176 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS:SiliconNXG469UTiSiXG478X1 7.6479e-20
C_2_177 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS:n1s 9.9987e-22
C_2_178 VDD:LM00Cobalt2XG483UTiSiXG476X1 VSS:n4d 8.2050e-20
C_2_179 VDD:LM00Cobalt2XG483UTiSiXG476X1 WLL 5.8718e-22
C_2_180 VDD:LM00Cobalt2XG483UTiSiXG476X1 WLR 5.8718e-22
C_2_181 VDD:LM00Cobalt2XG483UTiSiXG476X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.1772e-19
C_2_182 VDD:LM00Cobalt2XG483UTiSiXG476X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 3.9149e-23
C_2_183 VDD:LM00Cobalt2XG483UTiSiXG476X1 BLB:SiliconNXG67UTiSiXG68X1 1.6534e-22
C_2_184 VDD:LM00Cobalt2XG483UTiSiXG476X1 BLB:n3s 1.0796e-21
C_2_185 VDD:LM00Cobalt2XG483UTiSiXG476X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 5.7501e-20
C_2_186 VDD:LM00Cobalt2XG483UTiSiXG476X1 BL:LM00Cobalt2XG481UTiSiXG473X1 4.6845e-20
C_2_187 VDD:LM00Cobalt2XG483UTiSiXG476X1 BL:SiliconNXG468UTiSiXG473X1 1.5547e-20
C_2_188 VDD:LM00Cobalt2XG483UTiSiXG476X1 BL:n2d 2.1288e-20
C_2_189 VDD:LM00Cobalt2XG483UTiSiXG476X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.4818e-20
C_2_190 VDD:LM00Cobalt2XG483UTiSiXG476X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 9.2595e-22
C_2_191 VDD:LM00Cobalt2XG483UTiSiXG476X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 1.1330e-21
C_2_192 VDD:LM00Cobalt2XG483UTiSiXG476X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 1.5192e-22
C_2_193 VDD:LM00Cobalt2XG483UTiSiXG476X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 6.7723e-22
C_2_194 VDD:LM00Cobalt2XG483UTiSiXG476X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 4.6740e-22
C_2_195 VDD:LM00Cobalt2XG483UTiSiXG476X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 5.8793e-22
C_2_196 VDD:LM00Cobalt2XG483UTiSiXG476X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 1.2380e-22
C_2_197 VDD:LM00Cobalt2XG483UTiSiXG476X1 WL:n2g 1.5546e-21
C_2_198 VDD:LM00Cobalt2XG483UTiSiXG476X1 WL:n3g 3.9722e-22
C_2_199 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.9509e-18
C_2_200 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 3.1999e-20
C_2_201 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 3.1903e-20
C_2_202 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 3.1903e-20
C_2_203 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:SDexcludeXG241UTiSiXG270X1 8.7018e-22
C_2_204 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:SDexcludeXG245UTiSiXG269X1 4.1939e-22
C_2_205 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:SiGeBXG256UTiSiXG270X1 9.8125e-23
C_2_206 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:SiGeBXG257UTiSiXG270X1 9.3576e-25
C_2_207 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:SiGeBXG260UTiSiXG270X1 9.1382e-25
C_2_208 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:SiGeBXG286UTiSiXG270X1 9.8205e-25
C_2_209 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:SiGeBXG290UTiSiXG270X1 9.1093e-25
C_2_210 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:SiliconNXG274UTiSiXG269X1 2.7540e-23
C_2_211 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:n1d 4.4550e-22
C_2_212 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:n2s 4.4550e-22
C_2_213 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:n4g 3.7142e-21
C_2_214 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:p1d 9.6648e-22
C_2_215 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ1:p2g 1.0591e-19
C_2_216 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 3.1123e-20
C_2_217 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 2.6245e-20
C_2_218 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.6154e-20
C_2_219 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.6153e-20
C_2_220 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:SDexcludeXG242UTiSiXG271X1 8.4985e-22
C_2_221 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:SDexcludeXG246UTiSiXG272X1 4.6146e-22
C_2_222 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:SiGeBXG261UTiSiXG271X1 9.7201e-23
C_2_223 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:SiGeBXG262UTiSiXG271X1 3.0104e-24
C_2_224 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:SiGeBXG265UTiSiXG271X1 2.9953e-24
C_2_225 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:SiliconNXG276UTiSiXG272X1 2.4334e-23
C_2_226 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:n1g 3.7809e-22
C_2_227 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:n3d 4.8249e-22
C_2_228 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:n4s 4.8249e-22
C_2_229 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:p1g 3.8627e-22
C_2_230 VDD:LM00Cobalt2XG483UTiSiXG476X1 iQ2:p2s 9.4106e-22
C_2_231 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS 1.1301e-18
C_2_232 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 4.3066e-19
C_2_233 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS:LM00Cobalt2XG17UTiSiXG32X1 4.2522e-19
C_2_234 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 2.5766e-20
C_2_235 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS:LM00Cobalt2XG485UTiSiXG478X1 2.0879e-20
C_2_236 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 1.4222e-20
C_2_237 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 1.3205e-20
C_2_238 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 1.3652e-20
C_2_239 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 6.9690e-21
C_2_240 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS:SiliconNXG31UTiSiXG32X1 7.4655e-20
C_2_241 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS:SiliconNXG469UTiSiXG478X1 1.9148e-21
C_2_242 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS:n1s 7.9998e-20
C_2_243 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VSS:n4d 3.0990e-21
C_2_244 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 WLL 5.2558e-19
C_2_245 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 WLR 5.2558e-19
C_2_246 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.1670e-18
C_2_247 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 1.2239e-19
C_2_248 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 BLB:SiliconNXG67UTiSiXG68X1 2.0830e-20
C_2_249 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 BLB:n3s 2.7270e-20
C_2_250 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 1.2257e-18
C_2_251 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 BL:LM00Cobalt2XG481UTiSiXG473X1 7.3331e-20
C_2_252 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 BL:SiliconNXG468UTiSiXG473X1 6.0115e-21
C_2_253 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 BL:n2d 7.8581e-21
C_2_254 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.4096e-20
C_2_255 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 3.7524e-21
C_2_256 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 2.7264e-20
C_2_257 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 6.0946e-21
C_2_258 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 5.2741e-19
C_2_259 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 4.3025e-21
C_2_260 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 5.2698e-19
C_2_261 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 5.8540e-21
C_2_262 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 WL:n2g 7.5140e-22
C_2_263 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 WL:n3g 1.7743e-21
C_2_264 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 4.3722e-19
C_2_265 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 2.0748e-19
C_2_266 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 2.0700e-19
C_2_267 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 2.0701e-19
C_2_268 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:SDexcludeXG241UTiSiXG270X1 1.0258e-21
C_2_269 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:SDexcludeXG245UTiSiXG269X1 5.1950e-22
C_2_270 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:SiGeBXG256UTiSiXG270X1 4.9406e-22
C_2_271 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:SiGeBXG257UTiSiXG270X1 1.1495e-23
C_2_272 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:SiGeBXG260UTiSiXG270X1 1.1492e-23
C_2_273 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:SiGeBXG286UTiSiXG270X1 1.1549e-23
C_2_274 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:SiGeBXG290UTiSiXG270X1 1.1420e-23
C_2_275 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:SiliconNXG274UTiSiXG269X1 3.0858e-23
C_2_276 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:n1d 5.4612e-22
C_2_277 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:n2s 5.4612e-22
C_2_278 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:n4g 5.1147e-22
C_2_279 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:p1d 1.4970e-21
C_2_280 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ1:p2g 1.1301e-21
C_2_281 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.5657e-18
C_2_282 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 2.1217e-19
C_2_283 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.1169e-19
C_2_284 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.1168e-19
C_2_285 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:SDexcludeXG242UTiSiXG271X1 1.0449e-21
C_2_286 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:SDexcludeXG246UTiSiXG272X1 4.8113e-22
C_2_287 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:SiGeBXG261UTiSiXG271X1 4.9651e-22
C_2_288 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:SiGeBXG262UTiSiXG271X1 9.6872e-24
C_2_289 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:SiGeBXG265UTiSiXG271X1 9.6196e-24
C_2_290 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:SiliconNXG276UTiSiXG272X1 3.0837e-23
C_2_291 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:n1g 3.4961e-21
C_2_292 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:n3d 5.0895e-22
C_2_293 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:n4s 5.0895e-22
C_2_294 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:p1g 1.2969e-19
C_2_295 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 iQ2:p2s 1.5222e-21
C_2_296 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS 1.2851e-20
C_2_297 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 4.0850e-19
C_2_298 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS:LM00Cobalt2XG17UTiSiXG32X1 4.0803e-19
C_2_299 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 2.0374e-23
C_2_300 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS:LM00Cobalt2XG485UTiSiXG478X1 2.1103e-23
C_2_301 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 1.4705e-21
C_2_302 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 6.2930e-21
C_2_303 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 2.4497e-25
C_2_304 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 5.2547e-25
C_2_305 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS:SiliconNXG31UTiSiXG32X1 7.5984e-20
C_2_306 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS:SiliconNXG469UTiSiXG478X1 1.3763e-22
C_2_307 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS:n1s 8.1452e-20
C_2_308 VDD:LM00Cobalt2XG48UTiSiXG50X1 VSS:n4d 1.0074e-21
C_2_309 VDD:LM00Cobalt2XG48UTiSiXG50X1 WLL 5.4879e-22
C_2_310 VDD:LM00Cobalt2XG48UTiSiXG50X1 WLR 5.4879e-22
C_2_311 VDD:LM00Cobalt2XG48UTiSiXG50X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 5.9066e-20
C_2_312 VDD:LM00Cobalt2XG48UTiSiXG50X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 4.8343e-20
C_2_313 VDD:LM00Cobalt2XG48UTiSiXG50X1 BLB:SiliconNXG67UTiSiXG68X1 1.5528e-20
C_2_314 VDD:LM00Cobalt2XG48UTiSiXG50X1 BLB:n3s 2.1260e-20
C_2_315 VDD:LM00Cobalt2XG48UTiSiXG50X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 1.2091e-19
C_2_316 VDD:LM00Cobalt2XG48UTiSiXG50X1 BL:LM00Cobalt2XG481UTiSiXG473X1 3.9274e-23
C_2_317 VDD:LM00Cobalt2XG48UTiSiXG50X1 BL:SiliconNXG468UTiSiXG473X1 1.6681e-22
C_2_318 VDD:LM00Cobalt2XG48UTiSiXG50X1 BL:n2d 1.0897e-21
C_2_319 VDD:LM00Cobalt2XG48UTiSiXG50X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.1103e-21
C_2_320 VDD:LM00Cobalt2XG48UTiSiXG50X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 2.1278e-22
C_2_321 VDD:LM00Cobalt2XG48UTiSiXG50X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 1.5101e-20
C_2_322 VDD:LM00Cobalt2XG48UTiSiXG50X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 1.1414e-21
C_2_323 VDD:LM00Cobalt2XG48UTiSiXG50X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 5.4955e-22
C_2_324 VDD:LM00Cobalt2XG48UTiSiXG50X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 1.8830e-22
C_2_325 VDD:LM00Cobalt2XG48UTiSiXG50X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 5.9437e-22
C_2_326 VDD:LM00Cobalt2XG48UTiSiXG50X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 6.7142e-22
C_2_327 VDD:LM00Cobalt2XG48UTiSiXG50X1 WL:n2g 4.0261e-22
C_2_328 VDD:LM00Cobalt2XG48UTiSiXG50X1 WL:n3g 1.4977e-21
C_2_329 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 3.3725e-20
C_2_330 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 2.8645e-20
C_2_331 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 2.8546e-20
C_2_332 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 2.8548e-20
C_2_333 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:SDexcludeXG241UTiSiXG270X1 8.5900e-22
C_2_334 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:SDexcludeXG245UTiSiXG269X1 4.6388e-22
C_2_335 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:SiGeBXG256UTiSiXG270X1 1.0271e-22
C_2_336 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:SiGeBXG257UTiSiXG270X1 3.3565e-24
C_2_337 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:SiGeBXG260UTiSiXG270X1 3.3301e-24
C_2_338 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:SiGeBXG286UTiSiXG270X1 3.3137e-24
C_2_339 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:SiGeBXG290UTiSiXG270X1 3.3056e-24
C_2_340 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:SiliconNXG274UTiSiXG269X1 2.3241e-23
C_2_341 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:n1d 4.8509e-22
C_2_342 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:n2s 4.8509e-22
C_2_343 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:n4g 3.8037e-22
C_2_344 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:p1d 9.5510e-22
C_2_345 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ1:p2g 3.8876e-22
C_2_346 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.1854e-18
C_2_347 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 3.3679e-20
C_2_348 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.3580e-20
C_2_349 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 3.3580e-20
C_2_350 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:SDexcludeXG242UTiSiXG271X1 8.7517e-22
C_2_351 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:SDexcludeXG246UTiSiXG272X1 4.1984e-22
C_2_352 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:SiGeBXG261UTiSiXG271X1 1.0132e-22
C_2_353 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:SiGeBXG262UTiSiXG271X1 1.1469e-24
C_2_354 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:SiGeBXG265UTiSiXG271X1 1.1142e-24
C_2_355 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:SiliconNXG276UTiSiXG272X1 2.4240e-23
C_2_356 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:n1g 3.4870e-21
C_2_357 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:n3d 4.4308e-22
C_2_358 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:n4s 4.4308e-22
C_2_359 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:p1g 1.3128e-19
C_2_360 VDD:LM00Cobalt2XG48UTiSiXG50X1 iQ2:p2s 9.7427e-22
C_2_361 VDD:SiGeBXG465UTiSiXG476X1 VSS 7.2110e-22
C_2_362 VDD:SiGeBXG465UTiSiXG476X1 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 1.0392e-22
C_2_363 VDD:SiGeBXG465UTiSiXG476X1 VSS:LM00Cobalt2XG17UTiSiXG32X1 1.0990e-22
C_2_364 VDD:SiGeBXG465UTiSiXG476X1 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 5.3105e-20
C_2_365 VDD:SiGeBXG465UTiSiXG476X1 VSS:LM00Cobalt2XG485UTiSiXG478X1 5.5849e-20
C_2_366 VDD:SiGeBXG465UTiSiXG476X1 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 1.6779e-25
C_2_367 VDD:SiGeBXG465UTiSiXG476X1 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 1.2765e-24
C_2_368 VDD:SiGeBXG465UTiSiXG476X1 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 9.6089e-23
C_2_369 VDD:SiGeBXG465UTiSiXG476X1 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 5.6548e-22
C_2_370 VDD:SiGeBXG465UTiSiXG476X1 VSS:SiliconNXG31UTiSiXG32X1 7.9747e-22
C_2_371 VDD:SiGeBXG465UTiSiXG476X1 VSS:SiliconNXG469UTiSiXG478X1 1.5062e-19
C_2_372 VDD:SiGeBXG465UTiSiXG476X1 VSS:n1s 5.7798e-21
C_2_373 VDD:SiGeBXG465UTiSiXG476X1 VSS:n4d 2.1422e-19
C_2_374 VDD:SiGeBXG465UTiSiXG476X1 WLL 3.0142e-23
C_2_375 VDD:SiGeBXG465UTiSiXG476X1 WLR 3.0142e-23
C_2_376 VDD:SiGeBXG465UTiSiXG476X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 3.1131e-21
C_2_377 VDD:SiGeBXG465UTiSiXG476X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 1.4528e-22
C_2_378 VDD:SiGeBXG465UTiSiXG476X1 BLB:SiliconNXG67UTiSiXG68X1 1.0380e-21
C_2_379 VDD:SiGeBXG465UTiSiXG476X1 BLB:n3s 6.8434e-21
C_2_380 VDD:SiGeBXG465UTiSiXG476X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 1.6329e-20
C_2_381 VDD:SiGeBXG465UTiSiXG476X1 BL:LM00Cobalt2XG481UTiSiXG473X1 1.5294e-20
C_2_382 VDD:SiGeBXG465UTiSiXG476X1 BL:SiliconNXG468UTiSiXG473X1 1.6827e-20
C_2_383 VDD:SiGeBXG465UTiSiXG476X1 BL:n2d 3.4037e-20
C_2_384 VDD:SiGeBXG465UTiSiXG476X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 2.0718e-20
C_2_385 VDD:SiGeBXG465UTiSiXG476X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 2.8988e-22
C_2_386 VDD:SiGeBXG465UTiSiXG476X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 6.8868e-21
C_2_387 VDD:SiGeBXG465UTiSiXG476X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 1.0580e-23
C_2_388 VDD:SiGeBXG465UTiSiXG476X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 4.4393e-23
C_2_389 VDD:SiGeBXG465UTiSiXG476X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 1.0133e-22
C_2_390 VDD:SiGeBXG465UTiSiXG476X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 3.0229e-23
C_2_391 VDD:SiGeBXG465UTiSiXG476X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 4.1334e-24
C_2_392 VDD:SiGeBXG465UTiSiXG476X1 WL:n2g 6.3820e-23
C_2_393 VDD:SiGeBXG465UTiSiXG476X1 WL:n3g 2.4113e-23
C_2_394 VDD:SiGeBXG465UTiSiXG476X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.7127e-18
C_2_395 VDD:SiGeBXG465UTiSiXG476X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 2.0843e-21
C_2_396 VDD:SiGeBXG465UTiSiXG476X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.9546e-21
C_2_397 VDD:SiGeBXG465UTiSiXG476X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.9542e-21
C_2_398 VDD:SiGeBXG465UTiSiXG476X1 iQ1:SDexcludeXG241UTiSiXG270X1 4.7867e-21
C_2_399 VDD:SiGeBXG465UTiSiXG476X1 iQ1:SDexcludeXG245UTiSiXG269X1 2.1209e-21
C_2_400 VDD:SiGeBXG465UTiSiXG476X1 iQ1:SiGeBXG256UTiSiXG270X1 1.3030e-22
C_2_401 VDD:SiGeBXG465UTiSiXG476X1 iQ1:SiGeBXG257UTiSiXG270X1 1.1252e-25
C_2_402 VDD:SiGeBXG465UTiSiXG476X1 iQ1:SiGeBXG260UTiSiXG270X1 9.8227e-26
C_2_403 VDD:SiGeBXG465UTiSiXG476X1 iQ1:SiGeBXG286UTiSiXG270X1 1.0735e-25
C_2_404 VDD:SiGeBXG465UTiSiXG476X1 iQ1:SiGeBXG290UTiSiXG270X1 9.8478e-26
C_2_405 VDD:SiGeBXG465UTiSiXG476X1 iQ1:SiliconNXG274UTiSiXG269X1 9.1328e-23
C_2_406 VDD:SiGeBXG465UTiSiXG476X1 iQ1:n1d 2.2113e-21
C_2_407 VDD:SiGeBXG465UTiSiXG476X1 iQ1:n2s 2.2113e-21
C_2_408 VDD:SiGeBXG465UTiSiXG476X1 iQ1:n4g 1.3715e-22
C_2_409 VDD:SiGeBXG465UTiSiXG476X1 iQ1:p1d 4.9168e-21
C_2_410 VDD:SiGeBXG465UTiSiXG476X1 iQ1:p2g 1.5820e-21
C_2_411 VDD:SiGeBXG465UTiSiXG476X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.5614e-20
C_2_412 VDD:SiGeBXG465UTiSiXG476X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 2.6266e-22
C_2_413 VDD:SiGeBXG465UTiSiXG476X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.3509e-22
C_2_414 VDD:SiGeBXG465UTiSiXG476X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.3589e-22
C_2_415 VDD:SiGeBXG465UTiSiXG476X1 iQ2:SDexcludeXG242UTiSiXG271X1 5.9909e-21
C_2_416 VDD:SiGeBXG465UTiSiXG476X1 iQ2:SDexcludeXG246UTiSiXG272X1 3.0898e-21
C_2_417 VDD:SiGeBXG465UTiSiXG476X1 iQ2:SiGeBXG261UTiSiXG271X1 1.2762e-22
C_2_418 VDD:SiGeBXG465UTiSiXG476X1 iQ2:SiGeBXG262UTiSiXG271X1 4.3342e-26
C_2_419 VDD:SiGeBXG465UTiSiXG476X1 iQ2:SiGeBXG265UTiSiXG271X1 2.8451e-26
C_2_420 VDD:SiGeBXG465UTiSiXG476X1 iQ2:SiliconNXG276UTiSiXG272X1 1.2271e-22
C_2_421 VDD:SiGeBXG465UTiSiXG476X1 iQ2:n1g 2.1079e-23
C_2_422 VDD:SiGeBXG465UTiSiXG476X1 iQ2:n3d 3.2108e-21
C_2_423 VDD:SiGeBXG465UTiSiXG476X1 iQ2:n4s 3.2108e-21
C_2_424 VDD:SiGeBXG465UTiSiXG476X1 iQ2:p1g 2.1355e-23
C_2_425 VDD:SiGeBXG465UTiSiXG476X1 iQ2:p2s 6.1185e-21
C_2_426 VDD:SiGeBXG49UTiSiXG50X1 VSS 6.7489e-22
C_2_427 VDD:SiGeBXG49UTiSiXG50X1 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 5.3365e-20
C_2_428 VDD:SiGeBXG49UTiSiXG50X1 VSS:LM00Cobalt2XG17UTiSiXG32X1 5.6103e-20
C_2_429 VDD:SiGeBXG49UTiSiXG50X1 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 1.0343e-22
C_2_430 VDD:SiGeBXG49UTiSiXG50X1 VSS:LM00Cobalt2XG485UTiSiXG478X1 1.0942e-22
C_2_431 VDD:SiGeBXG49UTiSiXG50X1 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 8.6256e-23
C_2_432 VDD:SiGeBXG49UTiSiXG50X1 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 5.6772e-22
C_2_433 VDD:SiGeBXG49UTiSiXG50X1 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 1.4642e-25
C_2_434 VDD:SiGeBXG49UTiSiXG50X1 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 1.2654e-24
C_2_435 VDD:SiGeBXG49UTiSiXG50X1 VSS:SiliconNXG31UTiSiXG32X1 1.4914e-19
C_2_436 VDD:SiGeBXG49UTiSiXG50X1 VSS:SiliconNXG469UTiSiXG478X1 7.9821e-22
C_2_437 VDD:SiGeBXG49UTiSiXG50X1 VSS:n1s 2.1271e-19
C_2_438 VDD:SiGeBXG49UTiSiXG50X1 VSS:n4d 5.7830e-21
C_2_439 VDD:SiGeBXG49UTiSiXG50X1 WLL 2.7775e-23
C_2_440 VDD:SiGeBXG49UTiSiXG50X1 WLR 2.7775e-23
C_2_441 VDD:SiGeBXG49UTiSiXG50X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.6465e-20
C_2_442 VDD:SiGeBXG49UTiSiXG50X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 1.5460e-20
C_2_443 VDD:SiGeBXG49UTiSiXG50X1 BLB:SiliconNXG67UTiSiXG68X1 1.6696e-20
C_2_444 VDD:SiGeBXG49UTiSiXG50X1 BLB:n3s 3.3824e-20
C_2_445 VDD:SiGeBXG49UTiSiXG50X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 3.0951e-21
C_2_446 VDD:SiGeBXG49UTiSiXG50X1 BL:LM00Cobalt2XG481UTiSiXG473X1 1.4362e-22
C_2_447 VDD:SiGeBXG49UTiSiXG50X1 BL:SiliconNXG468UTiSiXG473X1 1.0405e-21
C_2_448 VDD:SiGeBXG49UTiSiXG50X1 BL:n2d 6.8654e-21
C_2_449 VDD:SiGeBXG49UTiSiXG50X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 6.7257e-21
C_2_450 VDD:SiGeBXG49UTiSiXG50X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 1.0718e-23
C_2_451 VDD:SiGeBXG49UTiSiXG50X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 2.1390e-20
C_2_452 VDD:SiGeBXG49UTiSiXG50X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 3.2965e-22
C_2_453 VDD:SiGeBXG49UTiSiXG50X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 2.7966e-23
C_2_454 VDD:SiGeBXG49UTiSiXG50X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 4.3187e-24
C_2_455 VDD:SiGeBXG49UTiSiXG50X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 3.4116e-23
C_2_456 VDD:SiGeBXG49UTiSiXG50X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 1.4457e-22
C_2_457 VDD:SiGeBXG49UTiSiXG50X1 WL:n2g 2.4248e-23
C_2_458 VDD:SiGeBXG49UTiSiXG50X1 WL:n3g 6.1830e-23
C_2_459 VDD:SiGeBXG49UTiSiXG50X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.5705e-20
C_2_460 VDD:SiGeBXG49UTiSiXG50X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 2.2413e-22
C_2_461 VDD:SiGeBXG49UTiSiXG50X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 9.6128e-23
C_2_462 VDD:SiGeBXG49UTiSiXG50X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 9.5905e-23
C_2_463 VDD:SiGeBXG49UTiSiXG50X1 iQ1:SDexcludeXG241UTiSiXG270X1 5.9979e-21
C_2_464 VDD:SiGeBXG49UTiSiXG50X1 iQ1:SDexcludeXG245UTiSiXG269X1 3.0940e-21
C_2_465 VDD:SiGeBXG49UTiSiXG50X1 iQ1:SiGeBXG256UTiSiXG270X1 1.2827e-22
C_2_466 VDD:SiGeBXG49UTiSiXG50X1 iQ1:SiGeBXG257UTiSiXG270X1 3.2302e-26
C_2_467 VDD:SiGeBXG49UTiSiXG50X1 iQ1:SiGeBXG260UTiSiXG270X1 2.4041e-26
C_2_468 VDD:SiGeBXG49UTiSiXG50X1 iQ1:SiGeBXG286UTiSiXG270X1 8.8490e-26
C_2_469 VDD:SiGeBXG49UTiSiXG50X1 iQ1:SiGeBXG290UTiSiXG270X1 2.3878e-26
C_2_470 VDD:SiGeBXG49UTiSiXG50X1 iQ1:SiliconNXG274UTiSiXG269X1 1.2296e-22
C_2_471 VDD:SiGeBXG49UTiSiXG50X1 iQ1:n1d 3.2164e-21
C_2_472 VDD:SiGeBXG49UTiSiXG50X1 iQ1:n2s 3.2164e-21
C_2_473 VDD:SiGeBXG49UTiSiXG50X1 iQ1:n4g 2.1037e-23
C_2_474 VDD:SiGeBXG49UTiSiXG50X1 iQ1:p1d 6.1261e-21
C_2_475 VDD:SiGeBXG49UTiSiXG50X1 iQ1:p2g 2.1260e-23
C_2_476 VDD:SiGeBXG49UTiSiXG50X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.6590e-18
C_2_477 VDD:SiGeBXG49UTiSiXG50X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 2.0111e-21
C_2_478 VDD:SiGeBXG49UTiSiXG50X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.8853e-21
C_2_479 VDD:SiGeBXG49UTiSiXG50X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.8856e-21
C_2_480 VDD:SiGeBXG49UTiSiXG50X1 iQ2:SDexcludeXG242UTiSiXG271X1 4.7818e-21
C_2_481 VDD:SiGeBXG49UTiSiXG50X1 iQ2:SDexcludeXG246UTiSiXG272X1 2.1132e-21
C_2_482 VDD:SiGeBXG49UTiSiXG50X1 iQ2:SiGeBXG261UTiSiXG271X1 1.2602e-22
C_2_483 VDD:SiGeBXG49UTiSiXG50X1 iQ2:SiGeBXG262UTiSiXG271X1 1.2703e-25
C_2_484 VDD:SiGeBXG49UTiSiXG50X1 iQ2:SiGeBXG265UTiSiXG271X1 1.0786e-25
C_2_485 VDD:SiGeBXG49UTiSiXG50X1 iQ2:SiliconNXG276UTiSiXG272X1 8.6660e-23
C_2_486 VDD:SiGeBXG49UTiSiXG50X1 iQ2:n1g 1.3553e-22
C_2_487 VDD:SiGeBXG49UTiSiXG50X1 iQ2:n3d 2.1991e-21
C_2_488 VDD:SiGeBXG49UTiSiXG50X1 iQ2:n4s 2.1991e-21
C_2_489 VDD:SiGeBXG49UTiSiXG50X1 iQ2:p1g 2.2596e-21
C_2_490 VDD:SiGeBXG49UTiSiXG50X1 iQ2:p2s 4.9076e-21
C_2_491 VDD:p1s VSS 7.4701e-22
C_2_492 VDD:p1s VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 5.9183e-20
C_2_493 VDD:p1s VSS:LM00Cobalt2XG17UTiSiXG32X1 6.2373e-20
C_2_494 VDD:p1s VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 7.1801e-22
C_2_495 VDD:p1s VSS:LM00Cobalt2XG485UTiSiXG478X1 7.5988e-22
C_2_496 VDD:p1s VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 9.1708e-23
C_2_497 VDD:p1s VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 6.2949e-22
C_2_498 VDD:p1s VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 1.0383e-24
C_2_499 VDD:p1s VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 8.6031e-24
C_2_500 VDD:p1s VSS:SiliconNXG31UTiSiXG32X1 2.1171e-19
C_2_501 VDD:p1s VSS:SiliconNXG469UTiSiXG478X1 5.5234e-21
C_2_502 VDD:p1s VSS:n1s 4.5280e-19
C_2_503 VDD:p1s VSS:n4d 3.9663e-20
C_2_504 VDD:p1s WLL 3.0582e-23
C_2_505 VDD:p1s WLR 3.0582e-23
C_2_506 VDD:p1s BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 2.1986e-20
C_2_507 VDD:p1s BLB:LM00Cobalt2XG64UTiSiXG68X1 2.0893e-20
C_2_508 VDD:p1s BLB:SiliconNXG67UTiSiXG68X1 3.4504e-20
C_2_509 VDD:p1s BLB:n3s 1.0392e-19
C_2_510 VDD:p1s BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 4.1268e-21
C_2_511 VDD:p1s BL:LM00Cobalt2XG481UTiSiXG473X1 1.0563e-21
C_2_512 VDD:p1s BL:SiliconNXG468UTiSiXG473X1 7.6404e-21
C_2_513 VDD:p1s BL:n2d 5.0487e-20
C_2_514 VDD:p1s WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 5.0903e-20
C_2_515 VDD:p1s WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 6.0175e-23
C_2_516 VDD:p1s WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 7.3686e-20
C_2_517 VDD:p1s WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 4.9985e-22
C_2_518 VDD:p1s WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 3.1732e-23
C_2_519 VDD:p1s WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 1.4742e-23
C_2_520 VDD:p1s WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 3.8644e-23
C_2_521 VDD:p1s WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 2.0045e-22
C_2_522 VDD:p1s iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.1745e-19
C_2_523 VDD:p1s iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.5971e-21
C_2_524 VDD:p1s iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.9192e-22
C_2_525 VDD:p1s iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.9113e-22
C_2_526 VDD:p1s iQ1:SDexcludeXG241UTiSiXG270X1 1.4365e-19
C_2_527 VDD:p1s iQ1:SDexcludeXG245UTiSiXG269X1 2.3233e-20
C_2_528 VDD:p1s iQ1:SiGeBXG256UTiSiXG270X1 1.4063e-21
C_2_529 VDD:p1s iQ1:SiGeBXG257UTiSiXG270X1 2.2808e-25
C_2_530 VDD:p1s iQ1:SiGeBXG260UTiSiXG270X1 1.6054e-25
C_2_531 VDD:p1s iQ1:SiGeBXG286UTiSiXG270X1 5.1440e-25
C_2_532 VDD:p1s iQ1:SiGeBXG290UTiSiXG270X1 1.5899e-25
C_2_533 VDD:p1s iQ1:SiliconNXG274UTiSiXG269X1 9.3397e-22
C_2_534 VDD:p1s iQ1:n1d 2.4166e-20
C_2_535 VDD:p1s iQ1:n2s 2.4166e-20
C_2_536 VDD:p1s iQ1:p1d 1.4505e-19
C_2_537 VDD:p1s iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 3.7184e-18
C_2_538 VDD:p1s iQ2:LM00Cobalt2XG118USiGeBXG261X1 3.0601e-21
C_2_539 VDD:p1s iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.2061e-21
C_2_540 VDD:p1s iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.2074e-21
C_2_541 VDD:p1s iQ2:SDexcludeXG242UTiSiXG271X1 3.3147e-20
C_2_542 VDD:p1s iQ2:SDexcludeXG246UTiSiXG272X1 1.3261e-20
C_2_543 VDD:p1s iQ2:SiGeBXG261UTiSiXG271X1 8.5442e-22
C_2_544 VDD:p1s iQ2:SiGeBXG262UTiSiXG271X1 3.3315e-25
C_2_545 VDD:p1s iQ2:SiGeBXG265UTiSiXG271X1 1.9065e-25
C_2_546 VDD:p1s iQ2:SiliconNXG276UTiSiXG272X1 5.0442e-22
C_2_547 VDD:p1s iQ2:n3d 1.3763e-20
C_2_548 VDD:p1s iQ2:n4s 1.3763e-20
C_2_549 VDD:p1s iQ2:p2s 3.4001e-20
C_2_550 VDD:p2d VSS 7.9865e-22
C_2_551 VDD:p2d VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 7.2169e-22
C_2_552 VDD:p2d VSS:LM00Cobalt2XG17UTiSiXG32X1 7.6355e-22
C_2_553 VDD:p2d VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 5.9034e-20
C_2_554 VDD:p2d VSS:LM00Cobalt2XG485UTiSiXG478X1 6.2230e-20
C_2_555 VDD:p2d VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 1.0346e-24
C_2_556 VDD:p2d VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 8.6670e-24
C_2_557 VDD:p2d VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 1.0218e-22
C_2_558 VDD:p2d VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 6.2781e-22
C_2_559 VDD:p2d VSS:SiliconNXG31UTiSiXG32X1 5.5200e-21
C_2_560 VDD:p2d VSS:SiliconNXG469UTiSiXG478X1 2.1327e-19
C_2_561 VDD:p2d VSS:n1s 3.9652e-20
C_2_562 VDD:p2d VSS:n4d 4.5426e-19
C_2_563 VDD:p2d WLL 3.3120e-23
C_2_564 VDD:p2d WLR 3.3120e-23
C_2_565 VDD:p2d BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 4.1725e-21
C_2_566 VDD:p2d BLB:LM00Cobalt2XG64UTiSiXG68X1 1.0687e-21
C_2_567 VDD:p2d BLB:SiliconNXG67UTiSiXG68X1 7.6218e-21
C_2_568 VDD:p2d BLB:n3s 5.0327e-20
C_2_569 VDD:p2d BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 2.1792e-20
C_2_570 VDD:p2d BL:LM00Cobalt2XG481UTiSiXG473X1 2.0660e-20
C_2_571 VDD:p2d BL:SiliconNXG468UTiSiXG473X1 3.4691e-20
C_2_572 VDD:p2d BL:n2d 1.0439e-19
C_2_573 VDD:p2d WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 7.1392e-20
C_2_574 VDD:p2d WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 4.4502e-22
C_2_575 VDD:p2d WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 5.2244e-20
C_2_576 VDD:p2d WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 6.3944e-23
C_2_577 VDD:p2d WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 5.1599e-23
C_2_578 VDD:p2d WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 1.4013e-22
C_2_579 VDD:p2d WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 3.3548e-23
C_2_580 VDD:p2d WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 1.8957e-23
C_2_581 VDD:p2d iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 3.7915e-18
C_2_582 VDD:p2d iQ1:LM00Cobalt2XG275USiGeBXG256X1 3.1633e-21
C_2_583 VDD:p2d iQ1:LM00Cobalt2XG275UTiSiXG269X1 2.2990e-21
C_2_584 VDD:p2d iQ1:LM00Cobalt2XG275UTiSiXG270X1 2.2983e-21
C_2_585 VDD:p2d iQ1:SDexcludeXG241UTiSiXG270X1 3.3165e-20
C_2_586 VDD:p2d iQ1:SDexcludeXG245UTiSiXG269X1 1.3299e-20
C_2_587 VDD:p2d iQ1:SiGeBXG256UTiSiXG270X1 8.6534e-22
C_2_588 VDD:p2d iQ1:SiGeBXG257UTiSiXG270X1 3.2541e-25
C_2_589 VDD:p2d iQ1:SiGeBXG260UTiSiXG270X1 1.8777e-25
C_2_590 VDD:p2d iQ1:SiGeBXG286UTiSiXG270X1 4.1491e-25
C_2_591 VDD:p2d iQ1:SiGeBXG290UTiSiXG270X1 1.8728e-25
C_2_592 VDD:p2d iQ1:SiliconNXG274UTiSiXG269X1 5.1800e-22
C_2_593 VDD:p2d iQ1:n1d 1.3816e-20
C_2_594 VDD:p2d iQ1:n2s 1.3816e-20
C_2_595 VDD:p2d iQ1:p1d 3.4030e-20
C_2_596 VDD:p2d iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.1642e-19
C_2_597 VDD:p2d iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.6488e-21
C_2_598 VDD:p2d iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.4882e-22
C_2_599 VDD:p2d iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.5175e-22
C_2_600 VDD:p2d iQ2:SDexcludeXG242UTiSiXG271X1 1.4341e-19
C_2_601 VDD:p2d iQ2:SDexcludeXG246UTiSiXG272X1 2.3195e-20
C_2_602 VDD:p2d iQ2:SiGeBXG261UTiSiXG271X1 1.4003e-21
C_2_603 VDD:p2d iQ2:SiGeBXG262UTiSiXG271X1 2.5125e-25
C_2_604 VDD:p2d iQ2:SiGeBXG265UTiSiXG271X1 1.7068e-25
C_2_605 VDD:p2d iQ2:SiliconNXG276UTiSiXG272X1 9.2502e-22
C_2_606 VDD:p2d iQ2:n3d 2.4114e-20
C_2_607 VDD:p2d iQ2:n4s 2.4114e-20
C_2_608 VDD:p2d iQ2:p2s 1.4481e-19
R_2_0 VDD VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 7.2881e+01
R_2_1 VDD VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 6.2937e+01
R_2_2 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VDD:LM00Cobalt2XG483UTiSiXG476X1 1.1796e+02
R_2_3 VDD:LM00Cobalt2XG483ULM40Cobalt5XG55X1 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 2.0136e+03
R_2_4 VDD:LM00Cobalt2XG483UTiSiXG476X1 VDD:SiGeBXG465UTiSiXG476X1 2.8738e+02
R_2_5 VDD:LM00Cobalt2XG48ULM40Cobalt5XG55X1 VDD:LM00Cobalt2XG48UTiSiXG50X1 9.5785e+01
R_2_6 VDD:LM00Cobalt2XG48UTiSiXG50X1 VDD:SiGeBXG49UTiSiXG50X1 2.6248e+02
R_2_7 VDD:SiGeBXG465UTiSiXG476X1 VDD:p2d 3.7421e+01
R_2_8 VDD:SiGeBXG49UTiSiXG50X1 VDD:p1s 3.7323e+01

*|NET VSS 6.5310e-05PF
C_3_0 BLBD VSS 6.9718e-19
C_3_1 BLBD VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 4.2725e-22
C_3_2 BLBD VSS:LM00Cobalt2XG17UTiSiXG32X1 3.8025e-22
C_3_3 BLBD VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 7.9788e-19
C_3_4 BLBD VSS:LM00Cobalt2XG485UTiSiXG478X1 2.5595e-19
C_3_5 BLBD VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 1.3600e-22
C_3_6 BLBD VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 7.2403e-23
C_3_7 BLBD VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 1.9456e-19
C_3_8 BLBD VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 6.1148e-19
C_3_9 BLBD VSS:SiliconNXG31UTiSiXG32X1 1.2999e-22
C_3_10 BLBD VSS:SiliconNXG469UTiSiXG478X1 5.5286e-21
C_3_11 BLBD VSS:n1s 2.2842e-22
C_3_12 BLBD VSS:n4d 5.6765e-21
C_3_13 BLBU VSS 6.9718e-19
C_3_14 BLBU VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 4.2725e-22
C_3_15 BLBU VSS:LM00Cobalt2XG17UTiSiXG32X1 3.8025e-22
C_3_16 BLBU VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 7.9788e-19
C_3_17 BLBU VSS:LM00Cobalt2XG485UTiSiXG478X1 2.5595e-19
C_3_18 BLBU VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 1.3600e-22
C_3_19 BLBU VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 7.2403e-23
C_3_20 BLBU VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 1.9456e-19
C_3_21 BLBU VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 6.1148e-19
C_3_22 BLBU VSS:SiliconNXG31UTiSiXG32X1 1.2999e-22
C_3_23 BLBU VSS:SiliconNXG469UTiSiXG478X1 5.5286e-21
C_3_24 BLBU VSS:n1s 2.2842e-22
C_3_25 BLBU VSS:n4d 5.6765e-21
C_3_26 BLD VSS 7.0601e-19
C_3_27 BLD VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 7.4282e-19
C_3_28 BLD VSS:LM00Cobalt2XG17UTiSiXG32X1 2.6419e-19
C_3_29 BLD VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 4.2118e-22
C_3_30 BLD VSS:LM00Cobalt2XG485UTiSiXG478X1 3.7607e-22
C_3_31 BLD VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 1.9359e-19
C_3_32 BLD VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 5.5199e-19
C_3_33 BLD VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 1.4039e-22
C_3_34 BLD VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 6.9386e-23
C_3_35 BLD VSS:SiliconNXG31UTiSiXG32X1 5.4510e-21
C_3_36 BLD VSS:SiliconNXG469UTiSiXG478X1 1.3133e-22
C_3_37 BLD VSS:n1s 5.5607e-21
C_3_38 BLD VSS:n4d 2.3191e-22
C_3_39 BLU VSS 7.0601e-19
C_3_40 BLU VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 7.4282e-19
C_3_41 BLU VSS:LM00Cobalt2XG17UTiSiXG32X1 2.6419e-19
C_3_42 BLU VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 4.2118e-22
C_3_43 BLU VSS:LM00Cobalt2XG485UTiSiXG478X1 3.7607e-22
C_3_44 BLU VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 1.9359e-19
C_3_45 BLU VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 5.5199e-19
C_3_46 BLU VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 1.4039e-22
C_3_47 BLU VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 6.9386e-23
C_3_48 BLU VSS:SiliconNXG31UTiSiXG32X1 5.4510e-21
C_3_49 BLU VSS:SiliconNXG469UTiSiXG478X1 1.3133e-22
C_3_50 BLU VSS:n1s 5.5607e-21
C_3_51 BLU VSS:n4d 2.3191e-22
C_3_52 VSS WLL 3.1170e-18
C_3_53 VSS WLR 3.1170e-18
C_3_54 VSS BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 7.4548e-19
C_3_55 VSS BLB:LM00Cobalt2XG64UTiSiXG68X1 4.8381e-20
C_3_56 VSS BLB:SiliconNXG67UTiSiXG68X1 2.0518e-21
C_3_57 VSS BLB:n3s 2.2070e-21
C_3_58 VSS BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 7.5826e-19
C_3_59 VSS BL:LM00Cobalt2XG481UTiSiXG473X1 5.2345e-20
C_3_60 VSS BL:SiliconNXG468UTiSiXG473X1 2.2581e-21
C_3_61 VSS BL:n2d 2.4284e-21
C_3_62 VSS WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 5.2303e-21
C_3_63 VSS WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 4.9673e-20
C_3_64 VSS WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 4.1346e-21
C_3_65 VSS WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 1.0296e-19
C_3_66 VSS WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 3.2976e-18
C_3_67 VSS WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 2.2705e-19
C_3_68 VSS WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 3.2690e-18
C_3_69 VSS WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 2.5252e-19
C_3_70 VSS WL:n2g 8.8583e-23
C_3_71 VSS WL:n3g 7.6114e-23
C_3_72 VSS iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 5.1937e-21
C_3_73 VSS iQ1:LM00Cobalt2XG275USiGeBXG256X1 6.9625e-22
C_3_74 VSS iQ1:LM00Cobalt2XG275UTiSiXG269X1 6.9511e-22
C_3_75 VSS iQ1:LM00Cobalt2XG275UTiSiXG270X1 6.9507e-22
C_3_76 VSS iQ1:SDexcludeXG241UTiSiXG270X1 1.9573e-23
C_3_77 VSS iQ1:SDexcludeXG245UTiSiXG269X1 1.1693e-23
C_3_78 VSS iQ1:SiGeBXG256UTiSiXG270X1 1.2026e-24
C_3_79 VSS iQ1:SiGeBXG257UTiSiXG270X1 1.0580e-26
C_3_80 VSS iQ1:SiGeBXG260UTiSiXG270X1 9.7484e-27
C_3_81 VSS iQ1:SiGeBXG286UTiSiXG270X1 6.0584e-25
C_3_82 VSS iQ1:SiGeBXG290UTiSiXG270X1 1.1167e-26
C_3_83 VSS iQ1:SiliconNXG274UTiSiXG269X1 8.7424e-25
C_3_84 VSS iQ1:n1d 1.2474e-23
C_3_85 VSS iQ1:n2s 1.2474e-23
C_3_86 VSS iQ1:n4g 2.1519e-23
C_3_87 VSS iQ1:p1d 2.0756e-23
C_3_88 VSS iQ1:p2g 3.2991e-23
C_3_89 VSS iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 4.6710e-21
C_3_90 VSS iQ2:LM00Cobalt2XG118USiGeBXG261X1 6.2967e-22
C_3_91 VSS iQ2:LM00Cobalt2XG118UTiSiXG271X1 6.2861e-22
C_3_92 VSS iQ2:LM00Cobalt2XG118UTiSiXG272X1 6.2866e-22
C_3_93 VSS iQ2:SDexcludeXG242UTiSiXG271X1 1.9293e-23
C_3_94 VSS iQ2:SDexcludeXG246UTiSiXG272X1 1.1416e-23
C_3_95 VSS iQ2:SiGeBXG261UTiSiXG271X1 1.0748e-24
C_3_96 VSS iQ2:SiGeBXG262UTiSiXG271X1 1.1267e-26
C_3_97 VSS iQ2:SiGeBXG265UTiSiXG271X1 1.0402e-26
C_3_98 VSS iQ2:SiliconNXG276UTiSiXG272X1 7.9227e-25
C_3_99 VSS iQ2:n1g 2.0512e-23
C_3_100 VSS iQ2:n3d 1.2101e-23
C_3_101 VSS iQ2:n4s 1.2101e-23
C_3_102 VSS iQ2:p1g 3.0685e-23
C_3_103 VSS iQ2:p2s 2.0347e-23
C_3_104 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 WLL 1.5889e-20
C_3_105 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 WLR 1.5889e-20
C_3_106 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.8305e-21
C_3_107 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 1.4242e-21
C_3_108 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 BLB:SiliconNXG67UTiSiXG68X1 7.5296e-22
C_3_109 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 BLB:n3s 1.7106e-21
C_3_110 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 7.4291e-19
C_3_111 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 BL:LM00Cobalt2XG481UTiSiXG473X1 9.6721e-23
C_3_112 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 BL:SiliconNXG468UTiSiXG473X1 1.4248e-22
C_3_113 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 BL:n2d 9.7049e-22
C_3_114 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 7.0316e-21
C_3_115 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 2.7249e-19
C_3_116 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 1.2021e-21
C_3_117 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 4.0500e-23
C_3_118 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 1.9754e-20
C_3_119 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 2.7317e-19
C_3_120 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 1.5892e-20
C_3_121 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 2.5640e-23
C_3_122 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 WL:n2g 4.7063e-22
C_3_123 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 WL:n3g 3.0065e-22
C_3_124 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 5.9789e-20
C_3_125 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 5.7608e-20
C_3_126 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 5.7728e-20
C_3_127 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 5.7592e-20
C_3_128 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:SDexcludeXG241UTiSiXG270X1 5.9304e-22
C_3_129 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:SDexcludeXG245UTiSiXG269X1 9.0623e-22
C_3_130 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:SiGeBXG256UTiSiXG270X1 1.6077e-23
C_3_131 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:SiGeBXG257UTiSiXG270X1 1.9496e-25
C_3_132 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:SiGeBXG260UTiSiXG270X1 1.9308e-25
C_3_133 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:SiGeBXG286UTiSiXG270X1 2.5018e-25
C_3_134 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:SiGeBXG290UTiSiXG270X1 1.9211e-25
C_3_135 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:SiliconNXG274UTiSiXG269X1 1.5837e-21
C_3_136 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:n1d 2.2175e-21
C_3_137 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:n2s 2.2175e-21
C_3_138 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:n4g 2.1616e-22
C_3_139 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:p1d 6.0873e-22
C_3_140 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ1:p2g 2.2560e-22
C_3_141 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.0236e-18
C_3_142 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 3.8292e-22
C_3_143 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.7201e-22
C_3_144 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 3.7202e-22
C_3_145 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:SDexcludeXG242UTiSiXG271X1 3.8800e-22
C_3_146 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.9463e-22
C_3_147 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:SiGeBXG261UTiSiXG271X1 1.0955e-23
C_3_148 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:SiGeBXG262UTiSiXG271X1 3.4754e-26
C_3_149 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:SiGeBXG265UTiSiXG271X1 2.4556e-26
C_3_150 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:SiliconNXG276UTiSiXG272X1 7.3555e-24
C_3_151 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:n1g 1.3216e-19
C_3_152 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:n3d 2.0192e-22
C_3_153 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:n4s 2.0192e-22
C_3_154 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:p1g 3.1779e-21
C_3_155 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 iQ2:p2s 3.9891e-22
C_3_156 VSS:LM00Cobalt2XG17UTiSiXG32X1 WLL 2.6202e-22
C_3_157 VSS:LM00Cobalt2XG17UTiSiXG32X1 WLR 2.6202e-22
C_3_158 VSS:LM00Cobalt2XG17UTiSiXG32X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.7588e-21
C_3_159 VSS:LM00Cobalt2XG17UTiSiXG32X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 1.3996e-21
C_3_160 VSS:LM00Cobalt2XG17UTiSiXG32X1 BLB:SiliconNXG67UTiSiXG68X1 7.7228e-22
C_3_161 VSS:LM00Cobalt2XG17UTiSiXG32X1 BLB:n3s 1.7802e-21
C_3_162 VSS:LM00Cobalt2XG17UTiSiXG32X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 2.6425e-19
C_3_163 VSS:LM00Cobalt2XG17UTiSiXG32X1 BL:LM00Cobalt2XG481UTiSiXG473X1 5.9516e-23
C_3_164 VSS:LM00Cobalt2XG17UTiSiXG32X1 BL:SiliconNXG468UTiSiXG473X1 1.4982e-22
C_3_165 VSS:LM00Cobalt2XG17UTiSiXG32X1 BL:n2d 1.0252e-21
C_3_166 VSS:LM00Cobalt2XG17UTiSiXG32X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 5.3498e-21
C_3_167 VSS:LM00Cobalt2XG17UTiSiXG32X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 1.4040e-20
C_3_168 VSS:LM00Cobalt2XG17UTiSiXG32X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 1.2510e-21
C_3_169 VSS:LM00Cobalt2XG17UTiSiXG32X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 3.8428e-23
C_3_170 VSS:LM00Cobalt2XG17UTiSiXG32X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 2.6534e-22
C_3_171 VSS:LM00Cobalt2XG17UTiSiXG32X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 1.2212e-20
C_3_172 VSS:LM00Cobalt2XG17UTiSiXG32X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 2.6405e-22
C_3_173 VSS:LM00Cobalt2XG17UTiSiXG32X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 2.3456e-23
C_3_174 VSS:LM00Cobalt2XG17UTiSiXG32X1 WL:n2g 4.9201e-22
C_3_175 VSS:LM00Cobalt2XG17UTiSiXG32X1 WL:n3g 3.1675e-22
C_3_176 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 4.8048e-20
C_3_177 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 4.5748e-20
C_3_178 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 4.5860e-20
C_3_179 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 4.5731e-20
C_3_180 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:SDexcludeXG241UTiSiXG270X1 6.2806e-22
C_3_181 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:SDexcludeXG245UTiSiXG269X1 9.3052e-22
C_3_182 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:SiGeBXG256UTiSiXG270X1 1.6851e-23
C_3_183 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:SiGeBXG257UTiSiXG270X1 1.9000e-25
C_3_184 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:SiGeBXG260UTiSiXG270X1 1.8866e-25
C_3_185 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:SiGeBXG286UTiSiXG270X1 1.9404e-25
C_3_186 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:SiGeBXG290UTiSiXG270X1 1.8748e-25
C_3_187 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:SiliconNXG274UTiSiXG269X1 1.5411e-21
C_3_188 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:n1d 2.2142e-21
C_3_189 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:n2s 2.2142e-21
C_3_190 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:n4g 2.2868e-22
C_3_191 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:p1d 6.4454e-22
C_3_192 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ1:p2g 2.3870e-22
C_3_193 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.0009e-18
C_3_194 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 3.7492e-22
C_3_195 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.6350e-22
C_3_196 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 3.6351e-22
C_3_197 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:SDexcludeXG242UTiSiXG271X1 4.1049e-22
C_3_198 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:SDexcludeXG246UTiSiXG272X1 2.0584e-22
C_3_199 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:SiGeBXG261UTiSiXG271X1 1.1472e-23
C_3_200 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:SiGeBXG262UTiSiXG271X1 3.3703e-26
C_3_201 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:SiGeBXG265UTiSiXG271X1 2.4150e-26
C_3_202 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:SiliconNXG276UTiSiXG272X1 7.7662e-24
C_3_203 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:n1g 1.3523e-19
C_3_204 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:n3d 2.1354e-22
C_3_205 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:n4s 2.1354e-22
C_3_206 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:p1g 3.2983e-21
C_3_207 VSS:LM00Cobalt2XG17UTiSiXG32X1 iQ2:p2s 4.2191e-22
C_3_208 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 WLL 2.4052e-20
C_3_209 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 WLR 2.4052e-20
C_3_210 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 7.9803e-19
C_3_211 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 1.4526e-22
C_3_212 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 BLB:SiliconNXG67UTiSiXG68X1 1.4184e-22
C_3_213 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 BLB:n3s 9.6254e-22
C_3_214 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 1.7924e-21
C_3_215 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 BL:LM00Cobalt2XG481UTiSiXG473X1 1.3918e-21
C_3_216 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 BL:SiliconNXG468UTiSiXG473X1 7.5491e-22
C_3_217 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 BL:n2d 1.7127e-21
C_3_218 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.1700e-21
C_3_219 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 3.2109e-23
C_3_220 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 9.2863e-21
C_3_221 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 2.6680e-19
C_3_222 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 2.4056e-20
C_3_223 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 1.8024e-23
C_3_224 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 3.1748e-20
C_3_225 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 2.6965e-19
C_3_226 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 WL:n2g 3.0395e-22
C_3_227 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 WL:n3g 4.6607e-22
C_3_228 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.7963e-18
C_3_229 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 3.9140e-22
C_3_230 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 3.8033e-22
C_3_231 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 3.8033e-22
C_3_232 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:SDexcludeXG241UTiSiXG270X1 3.8660e-22
C_3_233 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:SDexcludeXG245UTiSiXG269X1 1.9419e-22
C_3_234 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:SiGeBXG256UTiSiXG270X1 1.1117e-23
C_3_235 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:SiGeBXG257UTiSiXG270X1 3.8326e-26
C_3_236 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:SiGeBXG260UTiSiXG270X1 2.0902e-26
C_3_237 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:SiGeBXG286UTiSiXG270X1 2.4482e-26
C_3_238 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:SiGeBXG290UTiSiXG270X1 2.1049e-26
C_3_239 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:SiliconNXG274UTiSiXG269X1 7.5498e-24
C_3_240 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:n1d 2.0169e-22
C_3_241 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:n2s 2.0169e-22
C_3_242 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:n4g 1.0745e-19
C_3_243 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:p1d 3.9767e-22
C_3_244 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ1:p2g 3.3035e-21
C_3_245 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 6.0241e-20
C_3_246 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 5.8078e-20
C_3_247 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 5.8063e-20
C_3_248 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 5.8413e-20
C_3_249 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:SDexcludeXG242UTiSiXG271X1 5.8958e-22
C_3_250 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.1041e-21
C_3_251 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:SiGeBXG261UTiSiXG271X1 1.6049e-23
C_3_252 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:SiGeBXG262UTiSiXG271X1 2.0628e-25
C_3_253 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:SiGeBXG265UTiSiXG271X1 1.9354e-25
C_3_254 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:SiliconNXG276UTiSiXG272X1 1.8342e-21
C_3_255 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:n1g 2.1514e-22
C_3_256 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:n3d 2.2370e-21
C_3_257 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:n4s 2.2370e-21
C_3_258 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:p1g 2.2520e-22
C_3_259 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 iQ2:p2s 6.0524e-22
C_3_260 VSS:LM00Cobalt2XG485UTiSiXG478X1 WLL 2.9130e-22
C_3_261 VSS:LM00Cobalt2XG485UTiSiXG478X1 WLR 2.9130e-22
C_3_262 VSS:LM00Cobalt2XG485UTiSiXG478X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 2.5601e-19
C_3_263 VSS:LM00Cobalt2XG485UTiSiXG478X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 6.2899e-23
C_3_264 VSS:LM00Cobalt2XG485UTiSiXG478X1 BLB:SiliconNXG67UTiSiXG68X1 1.4861e-22
C_3_265 VSS:LM00Cobalt2XG485UTiSiXG478X1 BLB:n3s 1.0165e-21
C_3_266 VSS:LM00Cobalt2XG485UTiSiXG478X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 1.7234e-21
C_3_267 VSS:LM00Cobalt2XG485UTiSiXG478X1 BL:LM00Cobalt2XG481UTiSiXG473X1 1.3681e-21
C_3_268 VSS:LM00Cobalt2XG485UTiSiXG478X1 BL:SiliconNXG468UTiSiXG473X1 7.7442e-22
C_3_269 VSS:LM00Cobalt2XG485UTiSiXG478X1 BL:n2d 1.7828e-21
C_3_270 VSS:LM00Cobalt2XG485UTiSiXG478X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.2173e-21
C_3_271 VSS:LM00Cobalt2XG485UTiSiXG478X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 3.0799e-23
C_3_272 VSS:LM00Cobalt2XG485UTiSiXG478X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 5.7536e-21
C_3_273 VSS:LM00Cobalt2XG485UTiSiXG478X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 8.8496e-21
C_3_274 VSS:LM00Cobalt2XG485UTiSiXG478X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 2.9498e-22
C_3_275 VSS:LM00Cobalt2XG485UTiSiXG478X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 1.6431e-23
C_3_276 VSS:LM00Cobalt2XG485UTiSiXG478X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 2.9456e-22
C_3_277 VSS:LM00Cobalt2XG485UTiSiXG478X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 6.8096e-21
C_3_278 VSS:LM00Cobalt2XG485UTiSiXG478X1 WL:n2g 3.2025e-22
C_3_279 VSS:LM00Cobalt2XG485UTiSiXG478X1 WL:n3g 4.8506e-22
C_3_280 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.7613e-18
C_3_281 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 3.8284e-22
C_3_282 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 3.7125e-22
C_3_283 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 3.7124e-22
C_3_284 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:SDexcludeXG241UTiSiXG270X1 4.0909e-22
C_3_285 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:SDexcludeXG245UTiSiXG269X1 2.0542e-22
C_3_286 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:SiGeBXG256UTiSiXG270X1 1.1638e-23
C_3_287 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:SiGeBXG257UTiSiXG270X1 3.7081e-26
C_3_288 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:SiGeBXG260UTiSiXG270X1 2.0629e-26
C_3_289 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:SiGeBXG286UTiSiXG270X1 2.1462e-26
C_3_290 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:SiGeBXG290UTiSiXG270X1 2.0661e-26
C_3_291 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:SiliconNXG274UTiSiXG269X1 7.9695e-24
C_3_292 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:n1d 2.1334e-22
C_3_293 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:n2s 2.1334e-22
C_3_294 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:n4g 1.0955e-19
C_3_295 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:p1d 4.2069e-22
C_3_296 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ1:p2g 3.4252e-21
C_3_297 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 4.3130e-20
C_3_298 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 4.0852e-20
C_3_299 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 4.0835e-20
C_3_300 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 4.1154e-20
C_3_301 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:SDexcludeXG242UTiSiXG271X1 6.2456e-22
C_3_302 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.1020e-21
C_3_303 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:SiGeBXG261UTiSiXG271X1 1.6805e-23
C_3_304 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:SiGeBXG262UTiSiXG271X1 2.0026e-25
C_3_305 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:SiGeBXG265UTiSiXG271X1 1.8822e-25
C_3_306 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:SiliconNXG276UTiSiXG272X1 1.7315e-21
C_3_307 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:n1g 2.2767e-22
C_3_308 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:n3d 2.1961e-21
C_3_309 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:n4s 2.1961e-21
C_3_310 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:p1g 2.3834e-22
C_3_311 VSS:LM00Cobalt2XG485UTiSiXG478X1 iQ2:p2s 6.4099e-22
C_3_312 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 WLL 2.9398e-19
C_3_313 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 WLR 2.9398e-19
C_3_314 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.8300e-22
C_3_315 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 4.7323e-23
C_3_316 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 BLB:SiliconNXG67UTiSiXG68X1 7.2730e-24
C_3_317 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 BLB:n3s 9.7906e-24
C_3_318 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 1.9359e-19
C_3_319 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 BL:LM00Cobalt2XG481UTiSiXG473X1 2.5440e-24
C_3_320 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 BL:SiliconNXG468UTiSiXG473X1 2.9899e-25
C_3_321 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 BL:n2d 1.4609e-24
C_3_322 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 3.0240e-24
C_3_323 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 1.2476e-20
C_3_324 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 7.7247e-24
C_3_325 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 6.7673e-24
C_3_326 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 2.9741e-19
C_3_327 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 1.5903e-20
C_3_328 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 2.9400e-19
C_3_329 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 1.7234e-23
C_3_330 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 WL:n2g 5.3264e-25
C_3_331 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 WL:n3g 7.3739e-25
C_3_332 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.8450e-23
C_3_333 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.5148e-23
C_3_334 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.5136e-23
C_3_335 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.5130e-23
C_3_336 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:SDexcludeXG241UTiSiXG270X1 8.0904e-25
C_3_337 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:SDexcludeXG245UTiSiXG269X1 7.2075e-25
C_3_338 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:SiGeBXG256UTiSiXG270X1 1.8085e-26
C_3_339 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:SiGeBXG257UTiSiXG270X1 2.4264e-28
C_3_340 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:SiGeBXG260UTiSiXG270X1 1.6374e-28
C_3_341 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:SiGeBXG286UTiSiXG270X1 1.0267e-25
C_3_342 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:SiGeBXG290UTiSiXG270X1 3.3528e-28
C_3_343 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:SiliconNXG274UTiSiXG269X1 9.9348e-26
C_3_344 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:n1d 8.0714e-25
C_3_345 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:n2s 8.0714e-25
C_3_346 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:n4g 2.9937e-25
C_3_347 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:p1d 8.2680e-25
C_3_348 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ1:p2g 3.2517e-25
C_3_349 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.1201e-22
C_3_350 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 7.7648e-24
C_3_351 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 7.7404e-24
C_3_352 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 7.7405e-24
C_3_353 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:SDexcludeXG242UTiSiXG271X1 6.1093e-25
C_3_354 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:SDexcludeXG246UTiSiXG272X1 2.9545e-25
C_3_355 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:SiGeBXG261UTiSiXG271X1 2.4647e-26
C_3_356 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:SiGeBXG262UTiSiXG271X1 1.7620e-28
C_3_357 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:SiGeBXG265UTiSiXG271X1 1.2276e-28
C_3_358 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:SiliconNXG276UTiSiXG272X1 1.4907e-26
C_3_359 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:n1g 5.1085e-24
C_3_360 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:n3d 3.0992e-25
C_3_361 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:n4s 3.0992e-25
C_3_362 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:p1g 2.6530e-24
C_3_363 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 iQ2:p2s 6.3534e-25
C_3_364 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 WLL 4.0576e-20
C_3_365 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 WLR 4.0576e-20
C_3_366 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.5251e-22
C_3_367 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 8.0897e-23
C_3_368 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 BLB:SiliconNXG67UTiSiXG68X1 2.1225e-23
C_3_369 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 BLB:n3s 3.5640e-23
C_3_370 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 5.5203e-19
C_3_371 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 BL:LM00Cobalt2XG481UTiSiXG473X1 3.8958e-23
C_3_372 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 BL:SiliconNXG468UTiSiXG473X1 2.4233e-24
C_3_373 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 BL:n2d 1.2080e-23
C_3_374 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.7632e-21
C_3_375 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 2.6642e-19
C_3_376 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 2.5588e-23
C_3_377 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 4.0030e-24
C_3_378 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 4.6346e-20
C_3_379 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 2.7084e-19
C_3_380 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 4.0577e-20
C_3_381 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 3.6454e-24
C_3_382 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 WL:n2g 7.0329e-24
C_3_383 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 WL:n3g 4.3570e-24
C_3_384 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.1909e-20
C_3_385 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.1879e-20
C_3_386 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.1886e-20
C_3_387 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.1879e-20
C_3_388 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:SDexcludeXG241UTiSiXG270X1 7.0887e-24
C_3_389 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:SDexcludeXG245UTiSiXG269X1 1.8386e-23
C_3_390 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:SiGeBXG256UTiSiXG270X1 2.1237e-25
C_3_391 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:SiGeBXG257UTiSiXG270X1 5.2658e-27
C_3_392 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:SiGeBXG260UTiSiXG270X1 4.6751e-27
C_3_393 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:SiGeBXG286UTiSiXG270X1 9.1906e-26
C_3_394 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:SiGeBXG290UTiSiXG270X1 5.0028e-27
C_3_395 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:SiliconNXG274UTiSiXG269X1 4.9020e-23
C_3_396 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:n1d 5.1969e-23
C_3_397 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:n2s 5.1969e-23
C_3_398 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:n4g 2.6301e-24
C_3_399 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:p1d 7.2917e-24
C_3_400 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ1:p2g 2.7286e-24
C_3_401 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 3.3203e-20
C_3_402 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.8014e-23
C_3_403 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.7856e-23
C_3_404 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.7856e-23
C_3_405 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:SDexcludeXG242UTiSiXG271X1 4.8347e-24
C_3_406 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:SDexcludeXG246UTiSiXG272X1 2.4147e-24
C_3_407 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:SiGeBXG261UTiSiXG271X1 1.5926e-25
C_3_408 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:SiGeBXG262UTiSiXG271X1 1.4368e-27
C_3_409 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:SiGeBXG265UTiSiXG271X1 7.1322e-28
C_3_410 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:SiliconNXG276UTiSiXG272X1 9.8345e-26
C_3_411 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:n1g 1.5245e-22
C_3_412 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:n3d 2.5116e-24
C_3_413 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:n4s 2.5116e-24
C_3_414 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:p1g 2.1448e-23
C_3_415 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 iQ2:p2s 4.9925e-24
C_3_416 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 WLL 2.9747e-19
C_3_417 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 WLR 2.9747e-19
C_3_418 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.9456e-19
C_3_419 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 2.1397e-24
C_3_420 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 BLB:SiliconNXG67UTiSiXG68X1 2.7562e-25
C_3_421 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 BLB:n3s 1.4737e-24
C_3_422 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 1.9142e-22
C_3_423 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 BL:LM00Cobalt2XG481UTiSiXG473X1 5.1391e-23
C_3_424 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 BL:SiliconNXG468UTiSiXG473X1 8.1740e-24
C_3_425 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 BL:n2d 1.1019e-23
C_3_426 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 8.7795e-24
C_3_427 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 4.2130e-24
C_3_428 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 3.3058e-24
C_3_429 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 5.9488e-21
C_3_430 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 2.9749e-19
C_3_431 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 1.5711e-23
C_3_432 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 3.0050e-19
C_3_433 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 8.9750e-21
C_3_434 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 WL:n2g 8.6008e-25
C_3_435 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 WL:n3g 5.5181e-25
C_3_436 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 2.5767e-22
C_3_437 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 8.7319e-24
C_3_438 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 8.7013e-24
C_3_439 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 8.7010e-24
C_3_440 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:SDexcludeXG241UTiSiXG270X1 6.7517e-25
C_3_441 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:SDexcludeXG245UTiSiXG269X1 3.2281e-25
C_3_442 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:SiGeBXG256UTiSiXG270X1 3.1095e-26
C_3_443 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:SiGeBXG257UTiSiXG270X1 1.9558e-28
C_3_444 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:SiGeBXG260UTiSiXG270X1 1.0995e-28
C_3_445 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:SiGeBXG286UTiSiXG270X1 1.2824e-26
C_3_446 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:SiGeBXG290UTiSiXG270X1 4.7852e-28
C_3_447 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:SiliconNXG274UTiSiXG269X1 1.7905e-26
C_3_448 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:n1d 3.3992e-25
C_3_449 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:n2s 3.3992e-25
C_3_450 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:n4g 5.8054e-24
C_3_451 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:p1d 7.0604e-25
C_3_452 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ1:p2g 2.9767e-24
C_3_453 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.0818e-23
C_3_454 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.7521e-23
C_3_455 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.7495e-23
C_3_456 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.7518e-23
C_3_457 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:SDexcludeXG242UTiSiXG271X1 8.7060e-25
C_3_458 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:SDexcludeXG246UTiSiXG272X1 7.8896e-25
C_3_459 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:SiGeBXG261UTiSiXG271X1 2.6499e-26
C_3_460 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:SiGeBXG262UTiSiXG271X1 3.3262e-28
C_3_461 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:SiGeBXG265UTiSiXG271X1 2.3217e-28
C_3_462 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:SiliconNXG276UTiSiXG272X1 1.4174e-25
C_3_463 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:n1g 3.1334e-25
C_3_464 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:n3d 8.8391e-25
C_3_465 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:n4s 8.8391e-25
C_3_466 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:p1g 4.2952e-25
C_3_467 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 iQ2:p2s 8.9664e-25
C_3_468 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 WLL 4.8686e-20
C_3_469 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 WLR 4.8686e-20
C_3_470 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 6.1156e-19
C_3_471 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 8.4083e-23
C_3_472 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 BLB:SiliconNXG67UTiSiXG68X1 2.9724e-24
C_3_473 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 BLB:n3s 1.2697e-23
C_3_474 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 1.4755e-22
C_3_475 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 BL:LM00Cobalt2XG481UTiSiXG473X1 7.8947e-23
C_3_476 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 BL:SiliconNXG468UTiSiXG473X1 2.1263e-23
C_3_477 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 BL:n2d 3.5689e-23
C_3_478 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 2.5234e-23
C_3_479 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 2.7654e-24
C_3_480 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 3.6171e-21
C_3_481 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 2.6155e-19
C_3_482 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 4.8687e-20
C_3_483 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 2.6479e-24
C_3_484 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 5.8052e-20
C_3_485 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 2.6811e-19
C_3_486 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 WL:n2g 4.4339e-24
C_3_487 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 WL:n3g 9.2567e-24
C_3_488 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 4.5315e-20
C_3_489 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.8693e-23
C_3_490 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.8527e-23
C_3_491 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.8527e-23
C_3_492 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:SDexcludeXG241UTiSiXG270X1 4.8294e-24
C_3_493 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:SDexcludeXG245UTiSiXG269X1 2.4124e-24
C_3_494 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:SiGeBXG256UTiSiXG270X1 1.6742e-25
C_3_495 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:SiGeBXG257UTiSiXG270X1 1.5794e-27
C_3_496 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:SiGeBXG260UTiSiXG270X1 5.7398e-28
C_3_497 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:SiGeBXG286UTiSiXG270X1 8.2096e-27
C_3_498 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:SiGeBXG290UTiSiXG270X1 8.1852e-28
C_3_499 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:SiliconNXG274UTiSiXG269X1 1.0290e-25
C_3_500 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:n1d 2.5138e-24
C_3_501 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:n2s 2.5138e-24
C_3_502 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:n4g 2.2382e-22
C_3_503 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:p1d 4.9957e-24
C_3_504 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ1:p2g 2.2629e-23
C_3_505 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.7281e-20
C_3_506 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.7249e-20
C_3_507 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.7248e-20
C_3_508 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.7281e-20
C_3_509 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:SDexcludeXG242UTiSiXG271X1 7.0458e-24
C_3_510 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:SDexcludeXG246UTiSiXG272X1 4.5341e-23
C_3_511 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:SiGeBXG261UTiSiXG271X1 2.2544e-25
C_3_512 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:SiGeBXG262UTiSiXG271X1 6.4029e-27
C_3_513 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:SiGeBXG265UTiSiXG271X1 5.6140e-27
C_3_514 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:SiliconNXG276UTiSiXG272X1 1.1063e-22
C_3_515 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:n1g 2.6154e-24
C_3_516 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:n3d 9.0617e-23
C_3_517 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:n4s 9.0617e-23
C_3_518 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:p1g 2.7243e-24
C_3_519 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 iQ2:p2s 7.2600e-24
C_3_520 VSS:SiliconNXG31UTiSiXG32X1 WLL 1.5844e-23
C_3_521 VSS:SiliconNXG31UTiSiXG32X1 WLR 1.5844e-23
C_3_522 VSS:SiliconNXG31UTiSiXG32X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 1.2190e-21
C_3_523 VSS:SiliconNXG31UTiSiXG32X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 1.1168e-21
C_3_524 VSS:SiliconNXG31UTiSiXG32X1 BLB:SiliconNXG67UTiSiXG68X1 1.9409e-21
C_3_525 VSS:SiliconNXG31UTiSiXG32X1 BLB:n3s 7.6393e-21
C_3_526 VSS:SiliconNXG31UTiSiXG32X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 5.5899e-21
C_3_527 VSS:SiliconNXG31UTiSiXG32X1 BL:LM00Cobalt2XG481UTiSiXG473X1 1.4568e-22
C_3_528 VSS:SiliconNXG31UTiSiXG32X1 BL:SiliconNXG468UTiSiXG473X1 1.1024e-21
C_3_529 VSS:SiliconNXG31UTiSiXG32X1 BL:n2d 7.6139e-21
C_3_530 VSS:SiliconNXG31UTiSiXG32X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 1.0211e-20
C_3_531 VSS:SiliconNXG31UTiSiXG32X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 7.0961e-23
C_3_532 VSS:SiliconNXG31UTiSiXG32X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 5.8266e-21
C_3_533 VSS:SiliconNXG31UTiSiXG32X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 3.0087e-23
C_3_534 VSS:SiliconNXG31UTiSiXG32X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 1.6088e-23
C_3_535 VSS:SiliconNXG31UTiSiXG32X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 4.0100e-23
C_3_536 VSS:SiliconNXG31UTiSiXG32X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 1.6467e-23
C_3_537 VSS:SiliconNXG31UTiSiXG32X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 1.2821e-23
C_3_538 VSS:SiliconNXG31UTiSiXG32X1 WL:n2g 2.8225e-23
C_3_539 VSS:SiliconNXG31UTiSiXG32X1 WL:n3g 2.0210e-23
C_3_540 VSS:SiliconNXG31UTiSiXG32X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.3677e-20
C_3_541 VSS:SiliconNXG31UTiSiXG32X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 7.7532e-22
C_3_542 VSS:SiliconNXG31UTiSiXG32X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 6.9795e-22
C_3_543 VSS:SiliconNXG31UTiSiXG32X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 6.6370e-22
C_3_544 VSS:SiliconNXG31UTiSiXG32X1 iQ1:SDexcludeXG241UTiSiXG270X1 4.6723e-21
C_3_545 VSS:SiliconNXG31UTiSiXG32X1 iQ1:SDexcludeXG245UTiSiXG269X1 5.4813e-21
C_3_546 VSS:SiliconNXG31UTiSiXG32X1 iQ1:SiGeBXG256UTiSiXG270X1 1.1163e-22
C_3_547 VSS:SiliconNXG31UTiSiXG32X1 iQ1:SiGeBXG257UTiSiXG270X1 1.8870e-26
C_3_548 VSS:SiliconNXG31UTiSiXG32X1 iQ1:SiGeBXG260UTiSiXG270X1 1.0499e-26
C_3_549 VSS:SiliconNXG31UTiSiXG32X1 iQ1:SiGeBXG286UTiSiXG270X1 5.5001e-26
C_3_550 VSS:SiliconNXG31UTiSiXG32X1 iQ1:SiGeBXG290UTiSiXG270X1 1.0252e-26
C_3_551 VSS:SiliconNXG31UTiSiXG32X1 iQ1:SiliconNXG274UTiSiXG269X1 1.3197e-21
C_3_552 VSS:SiliconNXG31UTiSiXG32X1 iQ1:n1d 6.7325e-21
C_3_553 VSS:SiliconNXG31UTiSiXG32X1 iQ1:n2s 6.7325e-21
C_3_554 VSS:SiliconNXG31UTiSiXG32X1 iQ1:n4g 1.5027e-23
C_3_555 VSS:SiliconNXG31UTiSiXG32X1 iQ1:p1d 4.7839e-21
C_3_556 VSS:SiliconNXG31UTiSiXG32X1 iQ1:p2g 1.5700e-23
C_3_557 VSS:SiliconNXG31UTiSiXG32X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.5019e-18
C_3_558 VSS:SiliconNXG31UTiSiXG32X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 2.0412e-22
C_3_559 VSS:SiliconNXG31UTiSiXG32X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.3612e-22
C_3_560 VSS:SiliconNXG31UTiSiXG32X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.3625e-22
C_3_561 VSS:SiliconNXG31UTiSiXG32X1 iQ2:SDexcludeXG242UTiSiXG271X1 2.8231e-21
C_3_562 VSS:SiliconNXG31UTiSiXG32X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.4298e-21
C_3_563 VSS:SiliconNXG31UTiSiXG32X1 iQ2:SiGeBXG261UTiSiXG271X1 6.8020e-23
C_3_564 VSS:SiliconNXG31UTiSiXG32X1 iQ2:SiGeBXG262UTiSiXG271X1 1.5186e-26
C_3_565 VSS:SiliconNXG31UTiSiXG32X1 iQ2:SiGeBXG265UTiSiXG271X1 1.1675e-26
C_3_566 VSS:SiliconNXG31UTiSiXG32X1 iQ2:SiliconNXG276UTiSiXG272X1 5.2058e-23
C_3_567 VSS:SiliconNXG31UTiSiXG32X1 iQ2:n1g 3.2210e-21
C_3_568 VSS:SiliconNXG31UTiSiXG32X1 iQ2:n3d 1.4816e-21
C_3_569 VSS:SiliconNXG31UTiSiXG32X1 iQ2:n4s 1.4816e-21
C_3_570 VSS:SiliconNXG31UTiSiXG32X1 iQ2:p1g 1.4089e-22
C_3_571 VSS:SiliconNXG31UTiSiXG32X1 iQ2:p2s 2.8911e-21
C_3_572 VSS:SiliconNXG469UTiSiXG478X1 WLL 1.7448e-23
C_3_573 VSS:SiliconNXG469UTiSiXG478X1 WLR 1.7448e-23
C_3_574 VSS:SiliconNXG469UTiSiXG478X1 BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 5.6695e-21
C_3_575 VSS:SiliconNXG469UTiSiXG478X1 BLB:LM00Cobalt2XG64UTiSiXG68X1 1.4758e-22
C_3_576 VSS:SiliconNXG469UTiSiXG478X1 BLB:SiliconNXG67UTiSiXG68X1 1.1009e-21
C_3_577 VSS:SiliconNXG469UTiSiXG478X1 BLB:n3s 7.5993e-21
C_3_578 VSS:SiliconNXG469UTiSiXG478X1 BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 1.2057e-21
C_3_579 VSS:SiliconNXG469UTiSiXG478X1 BL:LM00Cobalt2XG481UTiSiXG473X1 1.1022e-21
C_3_580 VSS:SiliconNXG469UTiSiXG478X1 BL:SiliconNXG468UTiSiXG473X1 1.9499e-21
C_3_581 VSS:SiliconNXG469UTiSiXG478X1 BL:n2d 7.6715e-21
C_3_582 VSS:SiliconNXG469UTiSiXG478X1 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 5.6745e-21
C_3_583 VSS:SiliconNXG469UTiSiXG478X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 2.6387e-23
C_3_584 VSS:SiliconNXG469UTiSiXG478X1 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 1.0527e-20
C_3_585 VSS:SiliconNXG469UTiSiXG478X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 8.7354e-23
C_3_586 VSS:SiliconNXG469UTiSiXG478X1 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 1.8794e-23
C_3_587 VSS:SiliconNXG469UTiSiXG478X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 8.9498e-24
C_3_588 VSS:SiliconNXG469UTiSiXG478X1 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 1.7587e-23
C_3_589 VSS:SiliconNXG469UTiSiXG478X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 4.0952e-23
C_3_590 VSS:SiliconNXG469UTiSiXG478X1 WL:n2g 2.0468e-23
C_3_591 VSS:SiliconNXG469UTiSiXG478X1 WL:n3g 2.8054e-23
C_3_592 VSS:SiliconNXG469UTiSiXG478X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.5610e-18
C_3_593 VSS:SiliconNXG469UTiSiXG478X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 2.0757e-22
C_3_594 VSS:SiliconNXG469UTiSiXG478X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.3885e-22
C_3_595 VSS:SiliconNXG469UTiSiXG478X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.3881e-22
C_3_596 VSS:SiliconNXG469UTiSiXG478X1 iQ1:SDexcludeXG241UTiSiXG270X1 2.8276e-21
C_3_597 VSS:SiliconNXG469UTiSiXG478X1 iQ1:SDexcludeXG245UTiSiXG269X1 1.4339e-21
C_3_598 VSS:SiliconNXG469UTiSiXG478X1 iQ1:SiGeBXG256UTiSiXG270X1 6.8785e-23
C_3_599 VSS:SiliconNXG469UTiSiXG478X1 iQ1:SiGeBXG257UTiSiXG270X1 1.4613e-26
C_3_600 VSS:SiliconNXG469UTiSiXG478X1 iQ1:SiGeBXG260UTiSiXG270X1 1.3165e-26
C_3_601 VSS:SiliconNXG469UTiSiXG478X1 iQ1:SiGeBXG286UTiSiXG270X1 6.6088e-26
C_3_602 VSS:SiliconNXG469UTiSiXG478X1 iQ1:SiGeBXG290UTiSiXG270X1 1.3493e-26
C_3_603 VSS:SiliconNXG469UTiSiXG478X1 iQ1:SiliconNXG274UTiSiXG269X1 5.3022e-23
C_3_604 VSS:SiliconNXG469UTiSiXG478X1 iQ1:n1d 1.4868e-21
C_3_605 VSS:SiliconNXG469UTiSiXG478X1 iQ1:n2s 1.4868e-21
C_3_606 VSS:SiliconNXG469UTiSiXG478X1 iQ1:n4g 2.3214e-21
C_3_607 VSS:SiliconNXG469UTiSiXG478X1 iQ1:p1d 2.8964e-21
C_3_608 VSS:SiliconNXG469UTiSiXG478X1 iQ1:p2g 1.4333e-22
C_3_609 VSS:SiliconNXG469UTiSiXG478X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.3568e-20
C_3_610 VSS:SiliconNXG469UTiSiXG478X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 7.9008e-22
C_3_611 VSS:SiliconNXG469UTiSiXG478X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 6.7914e-22
C_3_612 VSS:SiliconNXG469UTiSiXG478X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 7.9217e-22
C_3_613 VSS:SiliconNXG469UTiSiXG478X1 iQ2:SDexcludeXG242UTiSiXG271X1 4.6715e-21
C_3_614 VSS:SiliconNXG469UTiSiXG478X1 iQ2:SDexcludeXG246UTiSiXG272X1 5.5661e-21
C_3_615 VSS:SiliconNXG469UTiSiXG478X1 iQ2:SiGeBXG261UTiSiXG271X1 1.1096e-22
C_3_616 VSS:SiliconNXG469UTiSiXG478X1 iQ2:SiGeBXG262UTiSiXG271X1 2.2061e-26
C_3_617 VSS:SiliconNXG469UTiSiXG478X1 iQ2:SiGeBXG265UTiSiXG271X1 9.8452e-27
C_3_618 VSS:SiliconNXG469UTiSiXG478X1 iQ2:SiliconNXG276UTiSiXG272X1 1.5231e-21
C_3_619 VSS:SiliconNXG469UTiSiXG478X1 iQ2:n1g 1.5021e-23
C_3_620 VSS:SiliconNXG469UTiSiXG478X1 iQ2:n3d 6.8631e-21
C_3_621 VSS:SiliconNXG469UTiSiXG478X1 iQ2:n4s 6.8631e-21
C_3_622 VSS:SiliconNXG469UTiSiXG478X1 iQ2:p1g 1.5735e-23
C_3_623 VSS:SiliconNXG469UTiSiXG478X1 iQ2:p2s 4.7824e-21
C_3_624 VSS:n1s WLL 1.7220e-23
C_3_625 VSS:n1s WLR 1.7220e-23
C_3_626 VSS:n1s BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 2.7054e-21
C_3_627 VSS:n1s BLB:LM00Cobalt2XG64UTiSiXG68X1 2.5589e-21
C_3_628 VSS:n1s BLB:SiliconNXG67UTiSiXG68X1 8.6168e-21
C_3_629 VSS:n1s BLB:n3s 4.4110e-20
C_3_630 VSS:n1s BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 6.6084e-21
C_3_631 VSS:n1s BL:LM00Cobalt2XG481UTiSiXG473X1 1.0989e-21
C_3_632 VSS:n1s BL:SiliconNXG468UTiSiXG473X1 8.4442e-21
C_3_633 VSS:n1s BL:n2d 5.9706e-20
C_3_634 VSS:n1s WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 7.7168e-20
C_3_635 VSS:n1s WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 1.4271e-22
C_3_636 VSS:n1s WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 3.5465e-20
C_3_637 VSS:n1s WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 8.9813e-23
C_3_638 VSS:n1s WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 1.8496e-23
C_3_639 VSS:n1s WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 6.2748e-23
C_3_640 VSS:n1s WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 1.8389e-23
C_3_641 VSS:n1s WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 3.1188e-23
C_3_642 VSS:n1s iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 9.5580e-20
C_3_643 VSS:n1s iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.8174e-21
C_3_644 VSS:n1s iQ1:LM00Cobalt2XG275UTiSiXG269X1 9.3298e-22
C_3_645 VSS:n1s iQ1:LM00Cobalt2XG275UTiSiXG270X1 8.8821e-22
C_3_646 VSS:n1s iQ1:SDexcludeXG241UTiSiXG270X1 3.5147e-20
C_3_647 VSS:n1s iQ1:SDexcludeXG245UTiSiXG269X1 8.4290e-20
C_3_648 VSS:n1s iQ1:SiGeBXG256UTiSiXG270X1 9.2934e-22
C_3_649 VSS:n1s iQ1:SiGeBXG257UTiSiXG270X1 1.2125e-25
C_3_650 VSS:n1s iQ1:SiGeBXG260UTiSiXG270X1 5.9855e-26
C_3_651 VSS:n1s iQ1:SiGeBXG286UTiSiXG270X1 3.1173e-25
C_3_652 VSS:n1s iQ1:SiGeBXG290UTiSiXG270X1 5.7625e-26
C_3_653 VSS:n1s iQ1:SiliconNXG274UTiSiXG269X1 3.5370e-21
C_3_654 VSS:n1s iQ1:n1d 8.7737e-20
C_3_655 VSS:n1s iQ1:n2s 8.7737e-20
C_3_656 VSS:n1s iQ1:p1d 3.6076e-20
C_3_657 VSS:n1s iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 3.5347e-18
C_3_658 VSS:n1s iQ2:LM00Cobalt2XG118USiGeBXG261X1 6.8680e-22
C_3_659 VSS:n1s iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.2464e-22
C_3_660 VSS:n1s iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.2550e-22
C_3_661 VSS:n1s iQ2:SDexcludeXG242UTiSiXG271X1 1.9208e-20
C_3_662 VSS:n1s iQ2:SDexcludeXG246UTiSiXG272X1 9.8707e-21
C_3_663 VSS:n1s iQ2:SiGeBXG261UTiSiXG271X1 4.6225e-22
C_3_664 VSS:n1s iQ2:SiGeBXG262UTiSiXG271X1 8.8165e-26
C_3_665 VSS:n1s iQ2:SiGeBXG265UTiSiXG271X1 4.9280e-26
C_3_666 VSS:n1s iQ2:SiliconNXG276UTiSiXG272X1 3.5627e-22
C_3_667 VSS:n1s iQ2:n3d 1.0225e-20
C_3_668 VSS:n1s iQ2:n4s 1.0225e-20
C_3_669 VSS:n1s iQ2:p2s 1.9670e-20
C_3_670 VSS:n4d WLL 1.8941e-23
C_3_671 VSS:n4d WLR 1.8941e-23
C_3_672 VSS:n4d BLB:LM00Cobalt2XG64ULM40Cobalt5XG61X1 6.7380e-21
C_3_673 VSS:n4d BLB:LM00Cobalt2XG64UTiSiXG68X1 1.1119e-21
C_3_674 VSS:n4d BLB:SiliconNXG67UTiSiXG68X1 8.4285e-21
C_3_675 VSS:n4d BLB:n3s 5.9562e-20
C_3_676 VSS:n4d BL:LM00Cobalt2XG481ULM40Cobalt5XG40X1 2.6746e-21
C_3_677 VSS:n4d BL:LM00Cobalt2XG481UTiSiXG473X1 2.5251e-21
C_3_678 VSS:n4d BL:SiliconNXG468UTiSiXG473X1 8.6411e-21
C_3_679 VSS:n4d BL:n2d 4.4259e-20
C_3_680 VSS:n4d WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 3.4564e-20
C_3_681 VSS:n4d WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 8.1091e-23
C_3_682 VSS:n4d WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 7.8829e-20
C_3_683 VSS:n4d WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 1.6696e-22
C_3_684 VSS:n4d WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 2.1626e-23
C_3_685 VSS:n4d WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 2.1641e-23
C_3_686 VSS:n4d WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 1.9450e-23
C_3_687 VSS:n4d WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 6.8773e-23
C_3_688 VSS:n4d iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 3.6114e-18
C_3_689 VSS:n4d iQ1:LM00Cobalt2XG275USiGeBXG256X1 6.9654e-22
C_3_690 VSS:n4d iQ1:LM00Cobalt2XG275UTiSiXG269X1 2.3059e-22
C_3_691 VSS:n4d iQ1:LM00Cobalt2XG275UTiSiXG270X1 2.3038e-22
C_3_692 VSS:n4d iQ1:SDexcludeXG241UTiSiXG270X1 1.9230e-20
C_3_693 VSS:n4d iQ1:SDexcludeXG245UTiSiXG269X1 9.8942e-21
C_3_694 VSS:n4d iQ1:SiGeBXG256UTiSiXG270X1 4.6629e-22
C_3_695 VSS:n4d iQ1:SiGeBXG257UTiSiXG270X1 8.3956e-26
C_3_696 VSS:n4d iQ1:SiGeBXG260UTiSiXG270X1 6.4755e-26
C_3_697 VSS:n4d iQ1:SiGeBXG286UTiSiXG270X1 4.1109e-25
C_3_698 VSS:n4d iQ1:SiGeBXG290UTiSiXG270X1 6.5129e-26
C_3_699 VSS:n4d iQ1:SiliconNXG274UTiSiXG269X1 3.6166e-22
C_3_700 VSS:n4d iQ1:n1d 1.0255e-20
C_3_701 VSS:n4d iQ1:n2s 1.0255e-20
C_3_702 VSS:n4d iQ1:p1d 1.9696e-20
C_3_703 VSS:n4d iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 9.4576e-20
C_3_704 VSS:n4d iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.8293e-21
C_3_705 VSS:n4d iQ2:LM00Cobalt2XG118UTiSiXG271X1 9.0644e-22
C_3_706 VSS:n4d iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.0506e-21
C_3_707 VSS:n4d iQ2:SDexcludeXG242UTiSiXG271X1 3.5124e-20
C_3_708 VSS:n4d iQ2:SDexcludeXG246UTiSiXG272X1 8.4342e-20
C_3_709 VSS:n4d iQ2:SiGeBXG261UTiSiXG271X1 9.2304e-22
C_3_710 VSS:n4d iQ2:SiGeBXG262UTiSiXG271X1 1.3540e-25
C_3_711 VSS:n4d iQ2:SiGeBXG265UTiSiXG271X1 6.6037e-26
C_3_712 VSS:n4d iQ2:SiliconNXG276UTiSiXG272X1 3.7737e-21
C_3_713 VSS:n4d iQ2:n3d 8.7827e-20
C_3_714 VSS:n4d iQ2:n4s 8.7827e-20
C_3_715 VSS:n4d iQ2:p2s 3.6047e-20
R_3_0 VSS VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 8.6081e+01
R_3_1 VSS VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 9.1399e+01
R_3_2 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 VSS:LM00Cobalt2XG17UTiSiXG32X1 2.3235e+02
R_3_3 VSS:LM00Cobalt2XG17ULM40Cobalt5XG21X1 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 3.0697e+02
R_3_4 VSS:LM00Cobalt2XG17UTiSiXG32X1 VSS:SiliconNXG31UTiSiXG32X1 2.3130e+02
R_3_5 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 VSS:LM00Cobalt2XG485UTiSiXG478X1 2.7102e+02
R_3_6 VSS:LM00Cobalt2XG485ULM40Cobalt5XG325X1 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 3.2693e+02
R_3_7 VSS:LM00Cobalt2XG485UTiSiXG478X1 VSS:SiliconNXG469UTiSiXG478X1 2.5915e+02
R_3_8 VSS:LM20Cobalt3XG23ULM30Cobalt4XG11X1 VSS:LM20Cobalt3XG23ULM40Cobalt5XG21X1 1.4436e+02
R_3_9 VSS:LM20Cobalt3XG463ULM30Cobalt4XG467X1 VSS:LM20Cobalt3XG463ULM40Cobalt5XG325X1 1.5650e+02
R_3_10 VSS:SiliconNXG31UTiSiXG32X1 VSS:n1s 4.0775e+01
R_3_11 VSS:SiliconNXG469UTiSiXG478X1 VSS:n4d 4.0810e+01

*|NET WL 9.4571e-05PF
C_4_0 WLL iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 2.2187e-22
C_4_1 WLL iQ1:LM00Cobalt2XG275USiGeBXG256X1 3.3512e-23
C_4_2 WLL iQ1:LM00Cobalt2XG275UTiSiXG269X1 3.3460e-23
C_4_3 WLL iQ1:LM00Cobalt2XG275UTiSiXG270X1 3.3458e-23
C_4_4 WLL iQ1:SDexcludeXG241UTiSiXG270X1 7.9399e-25
C_4_5 WLL iQ1:SDexcludeXG245UTiSiXG269X1 4.4606e-25
C_4_6 WLL iQ1:SiGeBXG256UTiSiXG270X1 5.5363e-26
C_4_7 WLL iQ1:SiGeBXG257UTiSiXG270X1 4.5522e-28
C_4_8 WLL iQ1:SiGeBXG260UTiSiXG270X1 4.3036e-28
C_4_9 WLL iQ1:SiGeBXG286UTiSiXG270X1 1.2181e-25
C_4_10 WLL iQ1:SiGeBXG290UTiSiXG270X1 8.3909e-28
C_4_11 WLL iQ1:SiliconNXG274UTiSiXG269X1 4.9119e-26
C_4_12 WLL iQ1:n1d 4.8963e-25
C_4_13 WLL iQ1:n2s 4.8963e-25
C_4_14 WLL iQ1:n4g 8.2775e-25
C_4_15 WLL iQ1:p1d 8.4850e-25
C_4_16 WLL iQ1:p2g 1.3296e-24
C_4_17 WLL iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.0007e-22
C_4_18 WLL iQ2:LM00Cobalt2XG118USiGeBXG261X1 3.1070e-23
C_4_19 WLL iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.1029e-23
C_4_20 WLL iQ2:LM00Cobalt2XG118UTiSiXG272X1 3.1032e-23
C_4_21 WLL iQ2:SDexcludeXG242UTiSiXG271X1 7.3893e-25
C_4_22 WLL iQ2:SDexcludeXG246UTiSiXG272X1 4.4083e-25
C_4_23 WLL iQ2:SiGeBXG261UTiSiXG271X1 4.1975e-26
C_4_24 WLL iQ2:SiGeBXG262UTiSiXG271X1 4.7725e-28
C_4_25 WLL iQ2:SiGeBXG265UTiSiXG271X1 4.6381e-28
C_4_26 WLL iQ2:SiliconNXG276UTiSiXG272X1 3.3505e-26
C_4_27 WLL iQ2:n1g 5.0172e-25
C_4_28 WLL iQ2:n3d 4.6799e-25
C_4_29 WLL iQ2:n4s 4.6799e-25
C_4_30 WLL iQ2:p1g 1.2851e-24
C_4_31 WLL iQ2:p2s 7.7999e-25
C_4_32 WLR iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 2.2187e-22
C_4_33 WLR iQ1:LM00Cobalt2XG275USiGeBXG256X1 3.3512e-23
C_4_34 WLR iQ1:LM00Cobalt2XG275UTiSiXG269X1 3.3460e-23
C_4_35 WLR iQ1:LM00Cobalt2XG275UTiSiXG270X1 3.3458e-23
C_4_36 WLR iQ1:SDexcludeXG241UTiSiXG270X1 7.9399e-25
C_4_37 WLR iQ1:SDexcludeXG245UTiSiXG269X1 4.4606e-25
C_4_38 WLR iQ1:SiGeBXG256UTiSiXG270X1 5.5363e-26
C_4_39 WLR iQ1:SiGeBXG257UTiSiXG270X1 4.5522e-28
C_4_40 WLR iQ1:SiGeBXG260UTiSiXG270X1 4.3036e-28
C_4_41 WLR iQ1:SiGeBXG286UTiSiXG270X1 1.2181e-25
C_4_42 WLR iQ1:SiGeBXG290UTiSiXG270X1 8.3909e-28
C_4_43 WLR iQ1:SiliconNXG274UTiSiXG269X1 4.9119e-26
C_4_44 WLR iQ1:n1d 4.8963e-25
C_4_45 WLR iQ1:n2s 4.8963e-25
C_4_46 WLR iQ1:n4g 8.2775e-25
C_4_47 WLR iQ1:p1d 8.4850e-25
C_4_48 WLR iQ1:p2g 1.3296e-24
C_4_49 WLR iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.0007e-22
C_4_50 WLR iQ2:LM00Cobalt2XG118USiGeBXG261X1 3.1070e-23
C_4_51 WLR iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.1029e-23
C_4_52 WLR iQ2:LM00Cobalt2XG118UTiSiXG272X1 3.1032e-23
C_4_53 WLR iQ2:SDexcludeXG242UTiSiXG271X1 7.3893e-25
C_4_54 WLR iQ2:SDexcludeXG246UTiSiXG272X1 4.4083e-25
C_4_55 WLR iQ2:SiGeBXG261UTiSiXG271X1 4.1975e-26
C_4_56 WLR iQ2:SiGeBXG262UTiSiXG271X1 4.7725e-28
C_4_57 WLR iQ2:SiGeBXG265UTiSiXG271X1 4.6381e-28
C_4_58 WLR iQ2:SiliconNXG276UTiSiXG272X1 3.3505e-26
C_4_59 WLR iQ2:n1g 5.0172e-25
C_4_60 WLR iQ2:n3d 4.6799e-25
C_4_61 WLR iQ2:n4s 4.6799e-25
C_4_62 WLR iQ2:p1g 1.2851e-24
C_4_63 WLR iQ2:p2s 7.7999e-25
C_4_64 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 4.5700e-18
C_4_65 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.3814e-18
C_4_66 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.3914e-18
C_4_67 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.3036e-18
C_4_68 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:SDexcludeXG241UTiSiXG270X1 1.0839e-19
C_4_69 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:SDexcludeXG245UTiSiXG269X1 7.0129e-19
C_4_70 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:SiGeBXG256UTiSiXG270X1 7.8276e-20
C_4_71 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:SiGeBXG257UTiSiXG270X1 2.2376e-22
C_4_72 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:SiGeBXG260UTiSiXG270X1 2.2375e-22
C_4_73 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:SiGeBXG286UTiSiXG270X1 2.2413e-22
C_4_74 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:SiGeBXG290UTiSiXG270X1 2.2375e-22
C_4_75 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:SiliconNXG274UTiSiXG269X1 7.9316e-19
C_4_76 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:n1d 1.3183e-18
C_4_77 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:n2s 1.3183e-18
C_4_78 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:n4g 1.0728e-20
C_4_79 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:p1d 1.8622e-19
C_4_80 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ1:p2g 1.5019e-20
C_4_81 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 7.0610e-19
C_4_82 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 5.2375e-22
C_4_83 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 8.0932e-23
C_4_84 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 8.1693e-23
C_4_85 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:SDexcludeXG242UTiSiXG271X1 1.7711e-20
C_4_86 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:SDexcludeXG246UTiSiXG272X1 8.5910e-21
C_4_87 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:SiGeBXG261UTiSiXG271X1 4.4290e-22
C_4_88 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:SiGeBXG262UTiSiXG271X1 1.4957e-25
C_4_89 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:SiGeBXG265UTiSiXG271X1 4.3547e-26
C_4_90 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:SiliconNXG276UTiSiXG272X1 3.1043e-22
C_4_91 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:n1g 1.1102e-19
C_4_92 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:n3d 8.8998e-21
C_4_93 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:n4s 8.8998e-21
C_4_94 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:p1g 3.2367e-20
C_4_95 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 iQ2:p2s 1.8154e-20
C_4_96 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.8774e-19
C_4_97 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.8244e-19
C_4_98 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.8255e-19
C_4_99 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.8244e-19
C_4_100 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:SDexcludeXG241UTiSiXG270X1 4.4141e-23
C_4_101 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:SDexcludeXG245UTiSiXG269X1 2.0082e-22
C_4_102 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:SiGeBXG256UTiSiXG270X1 3.3420e-24
C_4_103 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:SiGeBXG257UTiSiXG270X1 4.8102e-26
C_4_104 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:SiGeBXG260UTiSiXG270X1 4.4437e-26
C_4_105 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:SiGeBXG286UTiSiXG270X1 1.1728e-25
C_4_106 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:SiGeBXG290UTiSiXG270X1 4.4914e-26
C_4_107 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:SiliconNXG274UTiSiXG269X1 6.4585e-22
C_4_108 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:n1d 6.1915e-22
C_4_109 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:n2s 6.1915e-22
C_4_110 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:n4g 1.8245e-23
C_4_111 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:p1d 4.7394e-23
C_4_112 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ1:p2g 3.8378e-23
C_4_113 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 3.3098e-20
C_4_114 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 4.7878e-24
C_4_115 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 4.1337e-24
C_4_116 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 4.1334e-24
C_4_117 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:SDexcludeXG242UTiSiXG271X1 2.6433e-23
C_4_118 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.3029e-23
C_4_119 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:SiGeBXG261UTiSiXG271X1 6.5730e-25
C_4_120 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:SiGeBXG262UTiSiXG271X1 2.8708e-27
C_4_121 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:SiGeBXG265UTiSiXG271X1 1.6164e-27
C_4_122 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:SiliconNXG276UTiSiXG272X1 4.6193e-25
C_4_123 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:n1g 1.8519e-22
C_4_124 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:n3d 1.3489e-23
C_4_125 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:n4s 1.3489e-23
C_4_126 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:p1g 2.0636e-23
C_4_127 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 iQ2:p2s 2.7087e-23
C_4_128 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 7.3695e-19
C_4_129 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 5.4016e-22
C_4_130 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 8.1140e-23
C_4_131 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 8.0976e-23
C_4_132 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:SDexcludeXG241UTiSiXG270X1 1.8230e-20
C_4_133 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:SDexcludeXG245UTiSiXG269X1 8.8238e-21
C_4_134 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:SiGeBXG256UTiSiXG270X1 4.5930e-22
C_4_135 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:SiGeBXG257UTiSiXG270X1 1.5684e-25
C_4_136 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:SiGeBXG260UTiSiXG270X1 6.1981e-26
C_4_137 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:SiGeBXG286UTiSiXG270X1 4.1177e-25
C_4_138 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:SiGeBXG290UTiSiXG270X1 6.0987e-26
C_4_139 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:SiliconNXG274UTiSiXG269X1 3.2242e-22
C_4_140 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:n1d 9.1458e-21
C_4_141 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:n2s 9.1458e-21
C_4_142 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:n4g 1.1287e-19
C_4_143 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:p1d 1.8689e-20
C_4_144 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ1:p2g 3.3732e-20
C_4_145 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 4.7872e-18
C_4_146 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.3575e-18
C_4_147 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.2727e-18
C_4_148 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.3836e-18
C_4_149 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:SDexcludeXG242UTiSiXG271X1 1.1596e-19
C_4_150 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:SDexcludeXG246UTiSiXG272X1 7.3261e-19
C_4_151 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:SiGeBXG261UTiSiXG271X1 8.5495e-20
C_4_152 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:SiGeBXG262UTiSiXG271X1 3.3300e-22
C_4_153 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:SiGeBXG265UTiSiXG271X1 3.3297e-22
C_4_154 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:SiliconNXG276UTiSiXG272X1 8.4243e-19
C_4_155 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:n1g 1.1003e-20
C_4_156 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:n3d 1.3526e-18
C_4_157 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:n4s 1.3526e-18
C_4_158 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:p1g 1.5521e-20
C_4_159 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 iQ2:p2s 2.0079e-19
C_4_160 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 3.0602e-20
C_4_161 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 4.9301e-24
C_4_162 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 4.2045e-24
C_4_163 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 4.2054e-24
C_4_164 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:SDexcludeXG241UTiSiXG270X1 2.8662e-23
C_4_165 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:SDexcludeXG245UTiSiXG269X1 1.4145e-23
C_4_166 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:SiGeBXG256UTiSiXG270X1 7.2721e-25
C_4_167 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:SiGeBXG257UTiSiXG270X1 2.2084e-27
C_4_168 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:SiGeBXG260UTiSiXG270X1 1.2494e-27
C_4_169 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:SiGeBXG286UTiSiXG270X1 3.1960e-27
C_4_170 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:SiGeBXG290UTiSiXG270X1 1.2690e-27
C_4_171 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:SiliconNXG274UTiSiXG269X1 5.1945e-25
C_4_172 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:n1d 1.4663e-23
C_4_173 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:n2s 1.4663e-23
C_4_174 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:n4g 2.1469e-22
C_4_175 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:p1d 2.9387e-23
C_4_176 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ1:p2g 2.2129e-23
C_4_177 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.7176e-19
C_4_178 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.6628e-19
C_4_179 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.6627e-19
C_4_180 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.6668e-19
C_4_181 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:SDexcludeXG242UTiSiXG271X1 4.7398e-23
C_4_182 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:SDexcludeXG246UTiSiXG272X1 5.0446e-22
C_4_183 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:SiGeBXG261UTiSiXG271X1 3.0296e-24
C_4_184 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:SiGeBXG262UTiSiXG271X1 4.5414e-26
C_4_185 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:SiGeBXG265UTiSiXG271X1 4.3441e-26
C_4_186 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:SiliconNXG276UTiSiXG272X1 1.1977e-21
C_4_187 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:n1g 1.9733e-23
C_4_188 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:n3d 8.8909e-22
C_4_189 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:n4s 8.8909e-22
C_4_190 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:p1g 4.1978e-23
C_4_191 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 iQ2:p2s 5.0341e-23
C_4_192 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 4.2470e-22
C_4_193 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 6.7734e-23
C_4_194 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 6.7628e-23
C_4_195 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 6.7622e-23
C_4_196 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:SDexcludeXG241UTiSiXG270X1 1.6972e-24
C_4_197 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:SDexcludeXG245UTiSiXG269X1 1.1632e-24
C_4_198 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:SiGeBXG256UTiSiXG270X1 1.1358e-25
C_4_199 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:SiGeBXG257UTiSiXG270X1 7.9978e-28
C_4_200 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:SiGeBXG260UTiSiXG270X1 7.2821e-28
C_4_201 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:SiGeBXG286UTiSiXG270X1 2.1241e-25
C_4_202 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:SiGeBXG290UTiSiXG270X1 1.9226e-27
C_4_203 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:SiliconNXG274UTiSiXG269X1 1.0111e-25
C_4_204 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:n1d 1.2507e-24
C_4_205 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:n2s 1.2507e-24
C_4_206 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:n4g 1.2387e-24
C_4_207 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:p1d 1.8093e-24
C_4_208 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ1:p2g 2.4681e-24
C_4_209 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.0546e-22
C_4_210 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 3.1326e-23
C_4_211 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.1263e-23
C_4_212 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 3.1267e-23
C_4_213 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:SDexcludeXG242UTiSiXG271X1 1.3090e-24
C_4_214 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:SDexcludeXG246UTiSiXG272X1 7.1328e-25
C_4_215 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:SiGeBXG261UTiSiXG271X1 6.3948e-26
C_4_216 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:SiGeBXG262UTiSiXG271X1 5.8314e-28
C_4_217 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:SiGeBXG265UTiSiXG271X1 5.5938e-28
C_4_218 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:SiliconNXG276UTiSiXG272X1 6.1023e-26
C_4_219 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:n1g 1.0131e-24
C_4_220 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:n3d 7.6596e-25
C_4_221 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:n4s 7.6596e-25
C_4_222 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:p1g 1.6634e-24
C_4_223 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 iQ2:p2s 1.3719e-24
C_4_224 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 4.6971e-20
C_4_225 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 4.5482e-20
C_4_226 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 4.5492e-20
C_4_227 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 4.5482e-20
C_4_228 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:SDexcludeXG241UTiSiXG270X1 9.3828e-24
C_4_229 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:SDexcludeXG245UTiSiXG269X1 2.3033e-23
C_4_230 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:SiGeBXG256UTiSiXG270X1 7.0169e-25
C_4_231 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:SiGeBXG257UTiSiXG270X1 1.1365e-26
C_4_232 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:SiGeBXG260UTiSiXG270X1 1.0885e-26
C_4_233 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:SiGeBXG286UTiSiXG270X1 1.4152e-25
C_4_234 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:SiGeBXG290UTiSiXG270X1 1.1810e-26
C_4_235 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:SiliconNXG274UTiSiXG269X1 6.4118e-23
C_4_236 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:n1d 6.6365e-23
C_4_237 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:n2s 6.6365e-23
C_4_238 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:n4g 4.1224e-24
C_4_239 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:p1d 1.0063e-23
C_4_240 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ1:p2g 9.8965e-24
C_4_241 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.2256e-20
C_4_242 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 2.4395e-24
C_4_243 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.2875e-24
C_4_244 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.2879e-24
C_4_245 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:SDexcludeXG242UTiSiXG271X1 5.6962e-24
C_4_246 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:SDexcludeXG246UTiSiXG272X1 2.7614e-24
C_4_247 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:SiGeBXG261UTiSiXG271X1 1.5349e-25
C_4_248 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:SiGeBXG262UTiSiXG271X1 8.3226e-28
C_4_249 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:SiGeBXG265UTiSiXG271X1 7.4248e-28
C_4_250 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:SiliconNXG276UTiSiXG272X1 1.2169e-25
C_4_251 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:n1g 7.5056e-23
C_4_252 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:n3d 2.8809e-24
C_4_253 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:n4s 2.8809e-24
C_4_254 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:p1g 4.7590e-24
C_4_255 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 iQ2:p2s 5.8483e-24
C_4_256 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 2.2518e-22
C_4_257 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 3.3627e-23
C_4_258 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 3.3568e-23
C_4_259 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 3.3566e-23
C_4_260 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:SDexcludeXG241UTiSiXG270X1 1.0215e-24
C_4_261 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:SDexcludeXG245UTiSiXG269X1 5.5504e-25
C_4_262 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:SiGeBXG256UTiSiXG270X1 6.1816e-26
C_4_263 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:SiGeBXG257UTiSiXG270X1 4.8909e-28
C_4_264 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:SiGeBXG260UTiSiXG270X1 4.6191e-28
C_4_265 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:SiGeBXG286UTiSiXG270X1 1.2343e-25
C_4_266 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:SiGeBXG290UTiSiXG270X1 8.9243e-28
C_4_267 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:SiliconNXG274UTiSiXG269X1 5.3080e-26
C_4_268 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:n1d 6.0256e-25
C_4_269 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:n2s 6.0256e-25
C_4_270 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:n4g 1.0239e-24
C_4_271 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:p1d 1.0824e-24
C_4_272 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ1:p2g 1.4790e-24
C_4_273 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.8904e-22
C_4_274 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 4.7183e-23
C_4_275 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 4.7122e-23
C_4_276 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 4.7128e-23
C_4_277 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:SDexcludeXG242UTiSiXG271X1 1.0910e-24
C_4_278 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:SDexcludeXG246UTiSiXG272X1 7.1263e-25
C_4_279 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:SiGeBXG261UTiSiXG271X1 6.2312e-26
C_4_280 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:SiGeBXG262UTiSiXG271X1 6.3279e-28
C_4_281 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:SiGeBXG265UTiSiXG271X1 6.0944e-28
C_4_282 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:SiliconNXG276UTiSiXG272X1 5.5991e-26
C_4_283 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:n1g 6.7208e-25
C_4_284 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:n3d 7.5611e-25
C_4_285 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:n4s 7.5611e-25
C_4_286 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:p1g 1.7379e-24
C_4_287 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 iQ2:p2s 1.1521e-24
C_4_288 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.6456e-20
C_4_289 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:LM00Cobalt2XG275USiGeBXG256X1 2.6740e-24
C_4_290 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 2.4515e-24
C_4_291 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 2.4521e-24
C_4_292 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:SDexcludeXG241UTiSiXG270X1 8.2436e-24
C_4_293 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:SDexcludeXG245UTiSiXG269X1 4.0169e-24
C_4_294 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:SiGeBXG256UTiSiXG270X1 2.2332e-25
C_4_295 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:SiGeBXG257UTiSiXG270X1 7.0753e-28
C_4_296 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:SiGeBXG260UTiSiXG270X1 6.8257e-28
C_4_297 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:SiGeBXG286UTiSiXG270X1 3.6524e-27
C_4_298 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:SiGeBXG290UTiSiXG270X1 7.2622e-28
C_4_299 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:SiliconNXG274UTiSiXG269X1 1.4864e-25
C_4_300 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:n1d 4.1653e-24
C_4_301 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:n2s 4.1653e-24
C_4_302 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:n4g 6.9881e-23
C_4_303 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:p1d 8.4656e-24
C_4_304 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ1:p2g 6.5139e-24
C_4_305 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 3.9776e-20
C_4_306 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 3.7802e-20
C_4_307 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.7801e-20
C_4_308 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 3.7829e-20
C_4_309 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:SDexcludeXG242UTiSiXG271X1 1.3420e-23
C_4_310 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:SDexcludeXG246UTiSiXG272X1 4.3376e-23
C_4_311 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:SiGeBXG261UTiSiXG271X1 8.2907e-25
C_4_312 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:SiGeBXG262UTiSiXG271X1 1.0696e-26
C_4_313 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:SiGeBXG265UTiSiXG271X1 1.0345e-26
C_4_314 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:SiliconNXG276UTiSiXG272X1 8.9702e-23
C_4_315 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:n1g 5.8719e-24
C_4_316 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:n3d 7.7669e-23
C_4_317 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:n4s 7.7669e-23
C_4_318 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:p1g 1.4080e-23
C_4_319 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 iQ2:p2s 1.4228e-23
C_4_320 WL:n2g iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 2.8894e-19
C_4_321 WL:n2g iQ1:LM00Cobalt2XG275USiGeBXG256X1 9.4940e-20
C_4_322 WL:n2g iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.7218e-19
C_4_323 WL:n2g iQ1:LM00Cobalt2XG275UTiSiXG270X1 9.4945e-20
C_4_324 WL:n2g iQ1:SDexcludeXG241UTiSiXG270X1 4.7524e-24
C_4_325 WL:n2g iQ1:SDexcludeXG245UTiSiXG269X1 7.7237e-20
C_4_326 WL:n2g iQ1:SiGeBXG256UTiSiXG270X1 4.7524e-24
C_4_327 WL:n2g iQ1:SiGeBXG257UTiSiXG270X1 4.7524e-24
C_4_328 WL:n2g iQ1:SiGeBXG260UTiSiXG270X1 4.7524e-24
C_4_329 WL:n2g iQ1:SiGeBXG286UTiSiXG270X1 4.7524e-24
C_4_330 WL:n2g iQ1:SiGeBXG290UTiSiXG270X1 4.7524e-24
C_4_331 WL:n2g iQ1:SiliconNXG274UTiSiXG269X1 7.7237e-20
C_4_332 WL:n2g iQ1:n4g 4.0608e-21
C_4_333 WL:n2g iQ1:p2g 5.2042e-21
C_4_334 WL:n2g iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.3866e-19
C_4_335 WL:n2g iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.5051e-23
C_4_336 WL:n2g iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.5062e-23
C_4_337 WL:n2g iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.5357e-23
C_4_338 WL:n2g iQ2:SDexcludeXG242UTiSiXG271X1 1.0447e-26
C_4_339 WL:n2g iQ2:SDexcludeXG246UTiSiXG272X1 3.0541e-25
C_4_340 WL:n2g iQ2:SiGeBXG261UTiSiXG271X1 1.0447e-26
C_4_341 WL:n2g iQ2:SiGeBXG262UTiSiXG271X1 1.0447e-26
C_4_342 WL:n2g iQ2:SiGeBXG265UTiSiXG271X1 1.0447e-26
C_4_343 WL:n2g iQ2:SiliconNXG276UTiSiXG272X1 3.0541e-25
C_4_344 WL:n2g iQ2:n1g 3.0829e-20
C_4_345 WL:n2g iQ2:p1g 9.4007e-21
C_4_346 WL:n3g iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 1.3771e-19
C_4_347 WL:n3g iQ1:LM00Cobalt2XG275USiGeBXG256X1 1.5449e-23
C_4_348 WL:n3g iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.5532e-23
C_4_349 WL:n3g iQ1:LM00Cobalt2XG275UTiSiXG270X1 1.5467e-23
C_4_350 WL:n3g iQ1:SDexcludeXG241UTiSiXG270X1 1.7559e-26
C_4_351 WL:n3g iQ1:SDexcludeXG245UTiSiXG269X1 8.3187e-26
C_4_352 WL:n3g iQ1:SiGeBXG256UTiSiXG270X1 1.7559e-26
C_4_353 WL:n3g iQ1:SiGeBXG257UTiSiXG270X1 1.7559e-26
C_4_354 WL:n3g iQ1:SiGeBXG260UTiSiXG270X1 1.7559e-26
C_4_355 WL:n3g iQ1:SiGeBXG286UTiSiXG270X1 1.7559e-26
C_4_356 WL:n3g iQ1:SiGeBXG290UTiSiXG270X1 1.7559e-26
C_4_357 WL:n3g iQ1:SiliconNXG274UTiSiXG269X1 8.3187e-26
C_4_358 WL:n3g iQ1:n4g 3.0647e-20
C_4_359 WL:n3g iQ1:p2g 9.2002e-21
C_4_360 WL:n3g iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.7086e-19
C_4_361 WL:n3g iQ2:LM00Cobalt2XG118USiGeBXG261X1 9.3037e-20
C_4_362 WL:n3g iQ2:LM00Cobalt2XG118UTiSiXG271X1 9.3043e-20
C_4_363 WL:n3g iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.7171e-19
C_4_364 WL:n3g iQ2:SDexcludeXG242UTiSiXG271X1 5.4584e-24
C_4_365 WL:n3g iQ2:SDexcludeXG246UTiSiXG272X1 7.8673e-20
C_4_366 WL:n3g iQ2:SiGeBXG261UTiSiXG271X1 5.4584e-24
C_4_367 WL:n3g iQ2:SiGeBXG262UTiSiXG271X1 5.4584e-24
C_4_368 WL:n3g iQ2:SiGeBXG265UTiSiXG271X1 5.4584e-24
C_4_369 WL:n3g iQ2:SiliconNXG276UTiSiXG272X1 7.8673e-20
C_4_370 WL:n3g iQ2:n1g 4.0280e-21
C_4_371 WL:n3g iQ2:p1g 5.1628e-21
R_4_0 WLL WLR 5.4543e+00
R_4_1 WLL WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 3.3583e+01
R_4_2 WLL WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 1.9260e+03
R_4_3 WLR WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 1.8633e+03
R_4_4 WLR WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 3.4888e+01
R_4_5 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 1.3729e+02
R_4_6 WL:LM00Cobalt2XG307ULM10Tungsten1XG322X1 WL:n2g 4.6496e+01
R_4_7 WL:LM00Cobalt2XG307ULM40Cobalt5XG251X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 1.5156e+02
R_4_8 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 1.3732e+02
R_4_9 WL:LM00Cobalt2XG84ULM10Tungsten1XG144X1 WL:n3g 4.6311e+01
R_4_10 WL:LM00Cobalt2XG84ULM40Cobalt5XG76X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 1.4415e+02
R_4_11 WL:LM20Cobalt3XG283ULM30Cobalt4XG102X1 WL:LM20Cobalt3XG283ULM40Cobalt5XG251X1 5.8065e+01
R_4_12 WL:LM20Cobalt3XG81ULM30Cobalt4XG102X1 WL:LM20Cobalt3XG81ULM40Cobalt5XG76X1 5.9945e+01

*|NET iQ1 8.5549e-05PF
C_5_0 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 5.7187e-18
C_5_1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 3.0336e-18
C_5_2 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.1524e-18
C_5_3 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.2470e-18
C_5_4 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:SDexcludeXG242UTiSiXG271X1 9.9176e-19
C_5_5 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:SDexcludeXG246UTiSiXG272X1 7.5364e-19
C_5_6 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:SiGeBXG261UTiSiXG271X1 8.9968e-19
C_5_7 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:SiGeBXG262UTiSiXG271X1 9.2520e-21
C_5_8 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:SiGeBXG265UTiSiXG271X1 9.2518e-21
C_5_9 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:SiliconNXG276UTiSiXG272X1 8.3863e-19
C_5_10 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:n1g 1.5234e-19
C_5_11 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:n3d 1.3846e-18
C_5_12 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:n4s 1.3846e-18
C_5_13 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:p1g 2.0665e-19
C_5_14 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ2:p2s 1.8729e-18
C_5_15 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 3.0563e-18
C_5_16 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 6.2012e-20
C_5_17 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.4922e-20
C_5_18 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.4845e-20
C_5_19 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:SDexcludeXG242UTiSiXG271X1 5.9402e-21
C_5_20 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.5144e-22
C_5_21 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:SiGeBXG261UTiSiXG271X1 3.7243e-20
C_5_22 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:SiGeBXG262UTiSiXG271X1 7.6197e-23
C_5_23 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:SiGeBXG265UTiSiXG271X1 7.6140e-23
C_5_24 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:SiliconNXG276UTiSiXG272X1 6.1240e-24
C_5_25 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:n1g 9.4995e-20
C_5_26 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:n3d 1.5751e-22
C_5_27 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:n4s 1.5751e-22
C_5_28 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:p1g 8.4653e-20
C_5_29 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ2:p2s 4.3031e-20
C_5_30 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.2603e-18
C_5_31 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 2.4860e-20
C_5_32 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.2128e-20
C_5_33 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.2096e-20
C_5_34 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:SDexcludeXG242UTiSiXG271X1 2.3966e-22
C_5_35 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.3721e-23
C_5_36 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:SiGeBXG261UTiSiXG271X1 2.7966e-21
C_5_37 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:SiGeBXG262UTiSiXG271X1 3.1994e-23
C_5_38 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:SiGeBXG265UTiSiXG271X1 3.1959e-23
C_5_39 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:SiliconNXG276UTiSiXG272X1 5.1674e-25
C_5_40 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:n1g 1.7268e-19
C_5_41 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:n3d 1.4211e-23
C_5_42 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:n4s 1.4211e-23
C_5_43 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:p1g 8.4667e-20
C_5_44 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ2:p2s 2.9724e-21
C_5_45 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.1816e-18
C_5_46 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 2.4931e-20
C_5_47 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.2158e-20
C_5_48 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.2126e-20
C_5_49 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:SDexcludeXG242UTiSiXG271X1 2.4154e-22
C_5_50 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.3665e-23
C_5_51 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:SiGeBXG261UTiSiXG271X1 2.8376e-21
C_5_52 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:SiGeBXG262UTiSiXG271X1 3.2227e-23
C_5_53 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:SiGeBXG265UTiSiXG271X1 3.2191e-23
C_5_54 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:SiliconNXG276UTiSiXG272X1 5.1595e-25
C_5_55 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:n1g 9.4997e-20
C_5_56 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:n3d 1.4154e-23
C_5_57 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:n4s 1.4154e-23
C_5_58 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:p1g 9.1801e-20
C_5_59 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ2:p2s 3.0148e-21
C_5_60 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 9.9175e-19
C_5_61 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 5.9321e-21
C_5_62 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.3853e-22
C_5_63 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.3686e-22
C_5_64 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:SDexcludeXG242UTiSiXG271X1 3.1021e-20
C_5_65 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:SDexcludeXG246UTiSiXG272X1 5.4668e-21
C_5_66 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:SiGeBXG261UTiSiXG271X1 5.6979e-21
C_5_67 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:SiGeBXG262UTiSiXG271X1 2.1786e-24
C_5_68 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:SiGeBXG265UTiSiXG271X1 2.1648e-24
C_5_69 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:SiliconNXG276UTiSiXG272X1 2.1032e-22
C_5_70 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:n1g 1.7526e-24
C_5_71 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:n3d 5.6762e-21
C_5_72 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:n4s 5.6762e-21
C_5_73 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:p1g 7.1483e-21
C_5_74 iQ1:SDexcludeXG241UTiSiXG270X1 iQ2:p2s 3.6715e-20
C_5_75 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 7.3738e-19
C_5_76 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.5026e-22
C_5_77 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.3045e-23
C_5_78 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.3285e-23
C_5_79 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:SDexcludeXG242UTiSiXG271X1 5.4750e-21
C_5_80 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:SDexcludeXG246UTiSiXG272X1 2.7103e-21
C_5_81 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:SiGeBXG261UTiSiXG271X1 1.3724e-22
C_5_82 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:SiGeBXG262UTiSiXG271X1 1.6454e-26
C_5_83 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:SiGeBXG265UTiSiXG271X1 9.6701e-27
C_5_84 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:SiliconNXG276UTiSiXG272X1 9.7724e-23
C_5_85 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:n1g 7.7683e-20
C_5_86 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:n3d 2.8075e-21
C_5_87 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:n4s 2.8075e-21
C_5_88 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:p1g 1.4104e-23
C_5_89 iQ1:SDexcludeXG245UTiSiXG269X1 iQ2:p2s 5.6122e-21
C_5_90 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 8.9219e-19
C_5_91 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 3.7223e-20
C_5_92 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 2.8242e-21
C_5_93 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.7798e-21
C_5_94 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:SDexcludeXG242UTiSiXG271X1 5.7027e-21
C_5_95 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.3780e-22
C_5_96 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:SiGeBXG261UTiSiXG271X1 3.4487e-20
C_5_97 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:SiGeBXG262UTiSiXG271X1 4.4436e-23
C_5_98 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:SiGeBXG265UTiSiXG271X1 4.4414e-23
C_5_99 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:SiliconNXG276UTiSiXG272X1 5.6085e-24
C_5_100 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:n1g 1.7526e-24
C_5_101 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:n3d 1.4339e-22
C_5_102 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:n4s 1.4339e-22
C_5_103 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:p1g 7.1483e-21
C_5_104 iQ1:SiGeBXG256UTiSiXG270X1 iQ2:p2s 4.0101e-20
C_5_105 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 8.8158e-21
C_5_106 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 7.0754e-23
C_5_107 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.0195e-23
C_5_108 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.9962e-23
C_5_109 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:SDexcludeXG242UTiSiXG271X1 2.0573e-24
C_5_110 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.9640e-26
C_5_111 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:SiGeBXG261UTiSiXG271X1 4.1025e-23
C_5_112 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:SiGeBXG262UTiSiXG271X1 2.3351e-25
C_5_113 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:SiGeBXG265UTiSiXG271X1 2.3291e-25
C_5_114 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:SiliconNXG276UTiSiXG272X1 9.8829e-28
C_5_115 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:n1g 1.7526e-24
C_5_116 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:n3d 2.0603e-26
C_5_117 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:n4s 2.0603e-26
C_5_118 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:p1g 7.1483e-21
C_5_119 iQ1:SiGeBXG257UTiSiXG270X1 iQ2:p2s 4.2617e-23
C_5_120 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 8.7812e-21
C_5_121 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 7.0968e-23
C_5_122 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.0287e-23
C_5_123 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 3.0054e-23
C_5_124 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:SDexcludeXG242UTiSiXG271X1 2.0366e-24
C_5_125 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.4635e-26
C_5_126 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:SiGeBXG261UTiSiXG271X1 4.1147e-23
C_5_127 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:SiGeBXG262UTiSiXG271X1 2.3344e-25
C_5_128 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:SiGeBXG265UTiSiXG271X1 2.3283e-25
C_5_129 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:SiliconNXG276UTiSiXG272X1 2.4620e-28
C_5_130 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:n1g 1.7526e-24
C_5_131 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:n3d 1.4872e-26
C_5_132 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:n4s 1.4872e-26
C_5_133 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:p1g 7.1483e-21
C_5_134 iQ1:SiGeBXG260UTiSiXG270X1 iQ2:p2s 4.2718e-23
C_5_135 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 8.7395e-21
C_5_136 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 7.0711e-23
C_5_137 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.0163e-23
C_5_138 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.9931e-23
C_5_139 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:SDexcludeXG242UTiSiXG271X1 2.1585e-24
C_5_140 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.0295e-25
C_5_141 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:SiGeBXG261UTiSiXG271X1 4.1012e-23
C_5_142 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:SiGeBXG262UTiSiXG271X1 2.3264e-25
C_5_143 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:SiGeBXG265UTiSiXG271X1 2.3204e-25
C_5_144 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:SiliconNXG276UTiSiXG272X1 3.9071e-27
C_5_145 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:n1g 1.7526e-24
C_5_146 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:n3d 1.0683e-25
C_5_147 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:n4s 1.0683e-25
C_5_148 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:p1g 7.1483e-21
C_5_149 iQ1:SiGeBXG286UTiSiXG270X1 iQ2:p2s 4.2706e-23
C_5_150 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 8.7388e-21
C_5_151 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 7.0698e-23
C_5_152 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.0153e-23
C_5_153 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.9921e-23
C_5_154 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:SDexcludeXG242UTiSiXG271X1 2.0302e-24
C_5_155 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:SDexcludeXG246UTiSiXG272X1 1.4203e-26
C_5_156 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:SiGeBXG261UTiSiXG271X1 4.1009e-23
C_5_157 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:SiGeBXG262UTiSiXG271X1 2.3263e-25
C_5_158 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:SiGeBXG265UTiSiXG271X1 2.3203e-25
C_5_159 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:SiliconNXG276UTiSiXG272X1 2.3688e-28
C_5_160 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:n1g 1.7526e-24
C_5_161 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:n3d 1.4431e-26
C_5_162 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:n4s 1.4431e-26
C_5_163 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:p1g 7.1483e-21
C_5_164 iQ1:SiGeBXG290UTiSiXG270X1 iQ2:p2s 4.2575e-23
C_5_165 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 8.0683e-19
C_5_166 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:LM00Cobalt2XG118USiGeBXG261X1 6.2159e-24
C_5_167 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 5.3584e-25
C_5_168 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 5.5016e-25
C_5_169 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:SDexcludeXG242UTiSiXG271X1 2.1342e-22
C_5_170 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:SDexcludeXG246UTiSiXG272X1 9.8833e-23
C_5_171 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:SiGeBXG261UTiSiXG271X1 5.6807e-24
C_5_172 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:SiGeBXG262UTiSiXG271X1 1.4459e-27
C_5_173 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:SiGeBXG265UTiSiXG271X1 3.2728e-28
C_5_174 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:SiliconNXG276UTiSiXG272X1 3.5752e-24
C_5_175 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:n1g 7.7683e-20
C_5_176 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:n3d 1.0238e-22
C_5_177 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:n4s 1.0238e-22
C_5_178 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:p1g 1.4104e-23
C_5_179 iQ1:SiliconNXG274UTiSiXG269X1 iQ2:p2s 2.1910e-22
C_5_180 iQ1:n1d iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.3692e-18
C_5_181 iQ1:n1d iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.5645e-22
C_5_182 iQ1:n1d iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.3559e-23
C_5_183 iQ1:n1d iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.3813e-23
C_5_184 iQ1:n1d iQ2:SDexcludeXG242UTiSiXG271X1 5.6881e-21
C_5_185 iQ1:n1d iQ2:SDexcludeXG246UTiSiXG272X1 2.8090e-21
C_5_186 iQ1:n1d iQ2:SiGeBXG261UTiSiXG271X1 1.4291e-22
C_5_187 iQ1:n1d iQ2:SiGeBXG262UTiSiXG271X1 1.7814e-26
C_5_188 iQ1:n1d iQ2:SiGeBXG265UTiSiXG271X1 9.9177e-27
C_5_189 iQ1:n1d iQ2:SiliconNXG276UTiSiXG272X1 1.0130e-22
C_5_190 iQ1:n1d iQ2:n3d 2.9098e-21
C_5_191 iQ1:n1d iQ2:n4s 2.9098e-21
C_5_192 iQ1:n1d iQ2:p2s 5.8310e-21
C_5_193 iQ1:n2s iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.3692e-18
C_5_194 iQ1:n2s iQ2:LM00Cobalt2XG118USiGeBXG261X1 1.5645e-22
C_5_195 iQ1:n2s iQ2:LM00Cobalt2XG118UTiSiXG271X1 1.3559e-23
C_5_196 iQ1:n2s iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.3813e-23
C_5_197 iQ1:n2s iQ2:SDexcludeXG242UTiSiXG271X1 5.6881e-21
C_5_198 iQ1:n2s iQ2:SDexcludeXG246UTiSiXG272X1 2.8090e-21
C_5_199 iQ1:n2s iQ2:SiGeBXG261UTiSiXG271X1 1.4291e-22
C_5_200 iQ1:n2s iQ2:SiGeBXG262UTiSiXG271X1 1.7814e-26
C_5_201 iQ1:n2s iQ2:SiGeBXG265UTiSiXG271X1 9.9177e-27
C_5_202 iQ1:n2s iQ2:SiliconNXG276UTiSiXG272X1 1.0130e-22
C_5_203 iQ1:n2s iQ2:n3d 2.9098e-21
C_5_204 iQ1:n2s iQ2:n4s 2.9098e-21
C_5_205 iQ1:n2s iQ2:p2s 5.8310e-21
C_5_206 iQ1:n4g iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.4974e-19
C_5_207 iQ1:n4g iQ2:LM00Cobalt2XG118USiGeBXG261X1 9.3268e-20
C_5_208 iQ1:n4g iQ2:LM00Cobalt2XG118UTiSiXG271X1 9.3270e-20
C_5_209 iQ1:n4g iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.7168e-19
C_5_210 iQ1:n4g iQ2:SDexcludeXG242UTiSiXG271X1 2.4984e-24
C_5_211 iQ1:n4g iQ2:SDexcludeXG246UTiSiXG272X1 7.8417e-20
C_5_212 iQ1:n4g iQ2:SiGeBXG261UTiSiXG271X1 2.4984e-24
C_5_213 iQ1:n4g iQ2:SiGeBXG262UTiSiXG271X1 2.4984e-24
C_5_214 iQ1:n4g iQ2:SiGeBXG265UTiSiXG271X1 2.4984e-24
C_5_215 iQ1:n4g iQ2:SiliconNXG276UTiSiXG272X1 7.8417e-20
C_5_216 iQ1:n4g iQ2:n1g 3.8226e-21
C_5_217 iQ1:n4g iQ2:p1g 4.2374e-21
C_5_218 iQ1:p1d iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 1.8665e-18
C_5_219 iQ1:p1d iQ2:LM00Cobalt2XG118USiGeBXG261X1 4.3014e-20
C_5_220 iQ1:p1d iQ2:LM00Cobalt2XG118UTiSiXG271X1 3.0024e-21
C_5_221 iQ1:p1d iQ2:LM00Cobalt2XG118UTiSiXG272X1 2.9568e-21
C_5_222 iQ1:p1d iQ2:SDexcludeXG242UTiSiXG271X1 3.6720e-20
C_5_223 iQ1:p1d iQ2:SDexcludeXG246UTiSiXG272X1 5.6046e-21
C_5_224 iQ1:p1d iQ2:SiGeBXG261UTiSiXG271X1 4.0103e-20
C_5_225 iQ1:p1d iQ2:SiGeBXG262UTiSiXG271X1 4.6149e-23
C_5_226 iQ1:p1d iQ2:SiGeBXG265UTiSiXG271X1 4.6114e-23
C_5_227 iQ1:p1d iQ2:SiliconNXG276UTiSiXG272X1 2.1593e-22
C_5_228 iQ1:p1d iQ2:n3d 5.8195e-21
C_5_229 iQ1:p1d iQ2:n4s 5.8195e-21
C_5_230 iQ1:p1d iQ2:p2s 7.6731e-20
C_5_231 iQ1:p2g iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 2.0541e-19
C_5_232 iQ1:p2g iQ2:LM00Cobalt2XG118USiGeBXG261X1 8.4602e-20
C_5_233 iQ1:p2g iQ2:LM00Cobalt2XG118UTiSiXG271X1 9.1579e-20
C_5_234 iQ1:p2g iQ2:LM00Cobalt2XG118UTiSiXG272X1 8.4617e-20
C_5_235 iQ1:p2g iQ2:SDexcludeXG242UTiSiXG271X1 6.9764e-21
C_5_236 iQ1:p2g iQ2:SDexcludeXG246UTiSiXG272X1 1.4831e-23
C_5_237 iQ1:p2g iQ2:SiGeBXG261UTiSiXG271X1 6.9764e-21
C_5_238 iQ1:p2g iQ2:SiGeBXG262UTiSiXG271X1 6.9764e-21
C_5_239 iQ1:p2g iQ2:SiGeBXG265UTiSiXG271X1 6.9764e-21
C_5_240 iQ1:p2g iQ2:SiliconNXG276UTiSiXG272X1 1.4831e-23
C_5_241 iQ1:p2g iQ2:n1g 4.2259e-21
C_5_242 iQ1:p2g iQ2:p1g 7.2521e-21
R_5_0 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ1:LM00Cobalt2XG275UTiSiXG269X1 1.2220e+02
R_5_1 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 6.3845e+01
R_5_2 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ1:n4g 2.0354e+03
R_5_3 iQ1:LM00Cobalt2XG275ULM10Tungsten1XG323X1 iQ1:p2g 6.4771e+01
R_5_4 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 0.0000e+00
R_5_5 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ1:SDexcludeXG241UTiSiXG270X1 3.6582e+04
R_5_6 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ1:SiGeBXG256UTiSiXG270X1 0.0000e+00
R_5_7 iQ1:LM00Cobalt2XG275USiGeBXG256X1 iQ1:p1d 2.1014e+03
R_5_8 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ1:LM00Cobalt2XG275UTiSiXG270X1 3.1537e+01
R_5_9 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ1:SDexcludeXG245UTiSiXG269X1 2.8984e+04
R_5_10 iQ1:LM00Cobalt2XG275UTiSiXG269X1 iQ1:SiliconNXG274UTiSiXG269X1 1.5907e+02
R_5_11 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ1:SDexcludeXG241UTiSiXG270X1 5.7341e+02
R_5_12 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ1:SiGeBXG256UTiSiXG270X1 0.0000e+00
R_5_13 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ1:SiGeBXG286UTiSiXG270X1 2.2547e+03
R_5_14 iQ1:LM00Cobalt2XG275UTiSiXG270X1 iQ1:SiGeBXG290UTiSiXG270X1 2.2547e+03
R_5_15 iQ1:SDexcludeXG241UTiSiXG270X1 iQ1:SiGeBXG256UTiSiXG270X1 0.0000e+00
R_5_16 iQ1:SDexcludeXG241UTiSiXG270X1 iQ1:SiGeBXG257UTiSiXG270X1 0.0000e+00
R_5_17 iQ1:SDexcludeXG241UTiSiXG270X1 iQ1:SiGeBXG260UTiSiXG270X1 0.0000e+00
R_5_18 iQ1:SDexcludeXG241UTiSiXG270X1 iQ1:SiGeBXG286UTiSiXG270X1 0.0000e+00
R_5_19 iQ1:SDexcludeXG241UTiSiXG270X1 iQ1:SiGeBXG290UTiSiXG270X1 0.0000e+00
R_5_20 iQ1:SDexcludeXG241UTiSiXG270X1 iQ1:p1d 5.9522e+03
R_5_21 iQ1:SDexcludeXG245UTiSiXG269X1 iQ1:SiliconNXG274UTiSiXG269X1 0.0000e+00
R_5_22 iQ1:SDexcludeXG245UTiSiXG269X1 iQ1:n1d 3.1791e+02
R_5_23 iQ1:SDexcludeXG245UTiSiXG269X1 iQ1:n2s 3.1791e+02
R_5_24 iQ1:SiGeBXG256UTiSiXG270X1 iQ1:SiGeBXG257UTiSiXG270X1 0.0000e+00
R_5_25 iQ1:SiGeBXG256UTiSiXG270X1 iQ1:SiGeBXG260UTiSiXG270X1 0.0000e+00
R_5_26 iQ1:SiGeBXG256UTiSiXG270X1 iQ1:SiGeBXG286UTiSiXG270X1 0.0000e+00
R_5_27 iQ1:SiGeBXG256UTiSiXG270X1 iQ1:SiGeBXG290UTiSiXG270X1 0.0000e+00
R_5_28 iQ1:SiGeBXG256UTiSiXG270X1 iQ1:p1d 2.4627e+01
R_5_29 iQ1:SiliconNXG274UTiSiXG269X1 iQ1:n1d 6.1136e+01
R_5_30 iQ1:SiliconNXG274UTiSiXG269X1 iQ1:n2s 6.1136e+01
R_5_31 iQ1:n1d iQ1:n2s 0.0000e+00
R_5_32 iQ1:n4g iQ1:p2g 5.6954e+01

*|NET iQ2 8.6458e-05PF
R_6_0 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 6.3804e+01
R_6_1 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 1.2313e+02
R_6_2 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 iQ2:n1g 2.0219e+03
R_6_3 iQ2:LM00Cobalt2XG118ULM10Tungsten1XG129X1 iQ2:p1g 6.4792e+01
R_6_4 iQ2:LM00Cobalt2XG118USiGeBXG261X1 iQ2:LM00Cobalt2XG118UTiSiXG271X1 0.0000e+00
R_6_5 iQ2:LM00Cobalt2XG118USiGeBXG261X1 iQ2:SDexcludeXG242UTiSiXG271X1 7.7469e+04
R_6_6 iQ2:LM00Cobalt2XG118USiGeBXG261X1 iQ2:SiGeBXG261UTiSiXG271X1 0.0000e+00
R_6_7 iQ2:LM00Cobalt2XG118USiGeBXG261X1 iQ2:p2s 2.6650e+03
R_6_8 iQ2:LM00Cobalt2XG118UTiSiXG271X1 iQ2:LM00Cobalt2XG118UTiSiXG272X1 3.1616e+01
R_6_9 iQ2:LM00Cobalt2XG118UTiSiXG271X1 iQ2:SDexcludeXG242UTiSiXG271X1 5.6491e+02
R_6_10 iQ2:LM00Cobalt2XG118UTiSiXG271X1 iQ2:SiGeBXG261UTiSiXG271X1 0.0000e+00
R_6_11 iQ2:LM00Cobalt2XG118UTiSiXG271X1 iQ2:SiGeBXG262UTiSiXG271X1 2.2352e+03
R_6_12 iQ2:LM00Cobalt2XG118UTiSiXG271X1 iQ2:SiGeBXG265UTiSiXG271X1 2.3948e+03
R_6_13 iQ2:LM00Cobalt2XG118UTiSiXG272X1 iQ2:SDexcludeXG246UTiSiXG272X1 2.9662e+04
R_6_14 iQ2:LM00Cobalt2XG118UTiSiXG272X1 iQ2:SiliconNXG276UTiSiXG272X1 1.6450e+02
R_6_15 iQ2:SDexcludeXG242UTiSiXG271X1 iQ2:SiGeBXG261UTiSiXG271X1 0.0000e+00
R_6_16 iQ2:SDexcludeXG242UTiSiXG271X1 iQ2:SiGeBXG262UTiSiXG271X1 0.0000e+00
R_6_17 iQ2:SDexcludeXG242UTiSiXG271X1 iQ2:SiGeBXG265UTiSiXG271X1 0.0000e+00
R_6_18 iQ2:SDexcludeXG242UTiSiXG271X1 iQ2:p2s 1.2813e+04
R_6_19 iQ2:SDexcludeXG246UTiSiXG272X1 iQ2:SiliconNXG276UTiSiXG272X1 0.0000e+00
R_6_20 iQ2:SDexcludeXG246UTiSiXG272X1 iQ2:n3d 3.0988e+02
R_6_21 iQ2:SDexcludeXG246UTiSiXG272X1 iQ2:n4s 3.0988e+02
R_6_22 iQ2:SiGeBXG261UTiSiXG271X1 iQ2:SiGeBXG262UTiSiXG271X1 0.0000e+00
R_6_23 iQ2:SiGeBXG261UTiSiXG271X1 iQ2:SiGeBXG265UTiSiXG271X1 0.0000e+00
R_6_24 iQ2:SiGeBXG261UTiSiXG271X1 iQ2:p2s 2.4495e+01
R_6_25 iQ2:SiliconNXG276UTiSiXG272X1 iQ2:n3d 6.1474e+01
R_6_26 iQ2:SiliconNXG276UTiSiXG272X1 iQ2:n4s 6.1474e+01
R_6_27 iQ2:n1g iQ2:p1g 5.7078e+01
R_6_28 iQ2:n3d iQ2:n4s 0.0000e+00

*|INSTANCES
XMP1 iQ1:p1d iQ2:p1g VDD:p1s VBP pmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMP1_delta/(1**0.5)'
XMP2 VDD:p2d iQ1:p2g iQ2:p2s VBP pmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMP2_delta/(1**0.5)'
XMN1 iQ1:n1d iQ2:n1g VSS:n1s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMN1_delta/(1**0.5)'
XMN2 BL:n2d WL:n2g iQ1:n2s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMN2_delta/(1**0.5)'
XMN3 iQ2:n3d WL:n3g BLB:n3s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMN3_delta/(1**0.5)'
XMN4 VSS:n4d iQ1:n4g iQ2:n4s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMN4_delta/(1**0.5)'

.ENDS array_flat
