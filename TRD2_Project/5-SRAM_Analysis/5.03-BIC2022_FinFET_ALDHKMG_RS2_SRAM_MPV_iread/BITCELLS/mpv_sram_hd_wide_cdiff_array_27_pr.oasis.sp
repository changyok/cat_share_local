*|TITLE Netlist generated by Raphael FX rcnetmerge
*|TITLE 1.1
*|TITLE Date Fri Apr 23 16:01:54 PDT 2021
*|PARAM cellnamefrom= raphaelfx
*|PARAM include= {}
*|PARAM instancefrom= raphaelnet
*|PARAM outputnet= n957_rph.spf
*|PARAM pingroup=  WL {WLL WLR} BL {BLU BLD} BLB {BLBU BLBD}
*|PARAM pinsfrom= raphaelfx
*|PARAM raphaelnet= n957_rph.spi
*|PARAM referencenet= /nfs/pdx/disks/icf_sandp_gwa001/changyok/swb/SNPS_DTCO/TRD2/20201220/BIC2022_update20210412/2-RC_Extraction/2.01-BIC2022_FinFET_PEX_Nominal/sram_hd_wide.lvs

.SUBCKT array_flat BLBD BLBU BLD BLU VDD VSS WLL WLR VBP VBN

*|NETS BL BLB VDD VSS WL iQ1 iQ2

*|CAPACITANCE GRAND SUM 2.3756e-04PF
*|BLB WL 1.8150e-05PF
*|BLB iQ1 7.7551e-07PF
*|BLB iQ2 4.9087e-06PF
*|BL BLB 9.0025e-08PF
*|BL WL 1.7803e-05PF
*|BL iQ1 4.9021e-06PF
*|BL iQ2 7.4380e-07PF
*|VDD BL 1.1204e-05PF
*|VDD BLB 1.1194e-05PF
*|VDD VSS 9.9414e-06PF
*|VDD WL 6.8551e-06PF
*|VDD iQ1 1.3454e-05PF
*|VDD iQ2 1.3813e-05PF
*|VSS BL 7.5132e-06PF
*|VSS BLB 7.8163e-06PF
*|VSS WL 1.8793e-05PF
*|VSS iQ1 9.6806e-06PF
*|VSS iQ2 1.0032e-05PF
*|WL iQ1 1.5110e-05PF
*|WL iQ2 1.5336e-05PF
*|iQ1 iQ2 3.9443e-05PF

*|NET BL 4.2255e-05PF
C_0_0 BLBD BLD 2.0406e-21
C_0_1 BLBD BLU 2.0406e-21
C_0_2 BLBD BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 2.9979e-21
C_0_3 BLBD BL:LM00Cobalt2XG492UTiSiXG484X1 9.6778e-22
C_0_4 BLBD BL:SiliconNXG479UTiSiXG484X1 2.1293e-22
C_0_5 BLBD BL:n2d 3.3093e-22
C_0_6 BLBU BLD 2.0406e-21
C_0_7 BLBU BLU 2.0406e-21
C_0_8 BLBU BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 2.9979e-21
C_0_9 BLBU BL:LM00Cobalt2XG492UTiSiXG484X1 9.6778e-22
C_0_10 BLBU BL:SiliconNXG479UTiSiXG484X1 2.1293e-22
C_0_11 BLBU BL:n2d 3.3093e-22
C_0_12 BLD WLL 2.9253e-19
C_0_13 BLD WLR 2.9253e-19
C_0_14 BLD BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 3.0044e-21
C_0_15 BLD BLB:LM00Cobalt2XG63UTiSiXG66X1 9.7432e-22
C_0_16 BLD BLB:SiliconNXG67UTiSiXG66X1 2.1084e-22
C_0_17 BLD BLB:n3s 3.2952e-22
C_0_18 BLD WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.5094e-19
C_0_19 BLD WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 7.4287e-19
C_0_20 BLD WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 2.4649e-22
C_0_21 BLD WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 5.4533e-23
C_0_22 BLD WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 4.2517e-19
C_0_23 BLD WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 8.1275e-19
C_0_24 BLD WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 2.9254e-19
C_0_25 BLD WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 5.2375e-23
C_0_26 BLD WL:n2g 7.4177e-22
C_0_27 BLD WL:n3g 4.1050e-23
C_0_28 BLD iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 2.1997e-19
C_0_29 BLD iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.8655e-19
C_0_30 BLD iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.8656e-19
C_0_31 BLD iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.8653e-19
C_0_32 BLD iQ1:SDexcludeXG246UTiSiXG275X1 8.2521e-23
C_0_33 BLD iQ1:SDexcludeXG250UTiSiXG274X1 9.8108e-23
C_0_34 BLD iQ1:SiGeBXG261UTiSiXG275X1 2.5054e-23
C_0_35 BLD iQ1:SiGeBXG262UTiSiXG275X1 1.0660e-24
C_0_36 BLD iQ1:SiGeBXG265UTiSiXG275X1 1.0636e-24
C_0_37 BLD iQ1:SiGeBXG293UTiSiXG275X1 1.1152e-24
C_0_38 BLD iQ1:SiGeBXG297UTiSiXG275X1 1.0624e-24
C_0_39 BLD iQ1:SiliconNXG279UTiSiXG274X1 8.3541e-23
C_0_40 BLD iQ1:n1d 1.1006e-22
C_0_41 BLD iQ1:n2s 1.1006e-22
C_0_42 BLD iQ1:n4g 3.5897e-23
C_0_43 BLD iQ1:p1d 1.0545e-22
C_0_44 BLD iQ1:p2g 1.0106e-22
C_0_45 BLD iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.5949e-19
C_0_46 BLD iQ2:LM00Cobalt2XG117USiGeBXG266X1 5.2420e-22
C_0_47 BLD iQ2:LM00Cobalt2XG117UTiSiXG276X1 5.1745e-22
C_0_48 BLD iQ2:LM00Cobalt2XG117UTiSiXG277X1 5.1735e-22
C_0_49 BLD iQ2:SDexcludeXG247UTiSiXG276X1 4.9962e-23
C_0_50 BLD iQ2:SDexcludeXG251UTiSiXG277X1 2.3704e-23
C_0_51 BLD iQ2:SiGeBXG266UTiSiXG276X1 6.9836e-24
C_0_52 BLD iQ2:SiGeBXG267UTiSiXG276X1 1.1747e-25
C_0_53 BLD iQ2:SiGeBXG270UTiSiXG276X1 1.1506e-25
C_0_54 BLD iQ2:SiliconNXG281UTiSiXG277X1 1.1035e-24
C_0_55 BLD iQ2:n1g 4.5037e-22
C_0_56 BLD iQ2:n3d 2.4766e-23
C_0_57 BLD iQ2:n4s 2.4766e-23
C_0_58 BLD iQ2:p1g 1.9482e-22
C_0_59 BLD iQ2:p2s 5.6715e-23
C_0_60 BLU WLL 2.9253e-19
C_0_61 BLU WLR 2.9253e-19
C_0_62 BLU BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 3.0044e-21
C_0_63 BLU BLB:LM00Cobalt2XG63UTiSiXG66X1 9.7432e-22
C_0_64 BLU BLB:SiliconNXG67UTiSiXG66X1 2.1084e-22
C_0_65 BLU BLB:n3s 3.2952e-22
C_0_66 BLU WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.5094e-19
C_0_67 BLU WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 7.4287e-19
C_0_68 BLU WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 2.4649e-22
C_0_69 BLU WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 5.4533e-23
C_0_70 BLU WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 4.2517e-19
C_0_71 BLU WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 8.1275e-19
C_0_72 BLU WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 2.9254e-19
C_0_73 BLU WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 5.2375e-23
C_0_74 BLU WL:n2g 7.4177e-22
C_0_75 BLU WL:n3g 4.1050e-23
C_0_76 BLU iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 2.1997e-19
C_0_77 BLU iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.8655e-19
C_0_78 BLU iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.8656e-19
C_0_79 BLU iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.8653e-19
C_0_80 BLU iQ1:SDexcludeXG246UTiSiXG275X1 8.2521e-23
C_0_81 BLU iQ1:SDexcludeXG250UTiSiXG274X1 9.8108e-23
C_0_82 BLU iQ1:SiGeBXG261UTiSiXG275X1 2.5054e-23
C_0_83 BLU iQ1:SiGeBXG262UTiSiXG275X1 1.0660e-24
C_0_84 BLU iQ1:SiGeBXG265UTiSiXG275X1 1.0636e-24
C_0_85 BLU iQ1:SiGeBXG293UTiSiXG275X1 1.1152e-24
C_0_86 BLU iQ1:SiGeBXG297UTiSiXG275X1 1.0624e-24
C_0_87 BLU iQ1:SiliconNXG279UTiSiXG274X1 8.3541e-23
C_0_88 BLU iQ1:n1d 1.1006e-22
C_0_89 BLU iQ1:n2s 1.1006e-22
C_0_90 BLU iQ1:n4g 3.5897e-23
C_0_91 BLU iQ1:p1d 1.0545e-22
C_0_92 BLU iQ1:p2g 1.0106e-22
C_0_93 BLU iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.5949e-19
C_0_94 BLU iQ2:LM00Cobalt2XG117USiGeBXG266X1 5.2420e-22
C_0_95 BLU iQ2:LM00Cobalt2XG117UTiSiXG276X1 5.1745e-22
C_0_96 BLU iQ2:LM00Cobalt2XG117UTiSiXG277X1 5.1735e-22
C_0_97 BLU iQ2:SDexcludeXG247UTiSiXG276X1 4.9962e-23
C_0_98 BLU iQ2:SDexcludeXG251UTiSiXG277X1 2.3704e-23
C_0_99 BLU iQ2:SiGeBXG266UTiSiXG276X1 6.9836e-24
C_0_100 BLU iQ2:SiGeBXG267UTiSiXG276X1 1.1747e-25
C_0_101 BLU iQ2:SiGeBXG270UTiSiXG276X1 1.1506e-25
C_0_102 BLU iQ2:SiliconNXG281UTiSiXG277X1 1.1035e-24
C_0_103 BLU iQ2:n1g 4.5037e-22
C_0_104 BLU iQ2:n3d 2.4766e-23
C_0_105 BLU iQ2:n4s 2.4766e-23
C_0_106 BLU iQ2:p1g 1.9482e-22
C_0_107 BLU iQ2:p2s 5.6715e-23
C_0_108 WLL BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 2.9479e-19
C_0_109 WLL BL:LM00Cobalt2XG492UTiSiXG484X1 2.2605e-21
C_0_110 WLL BL:SiliconNXG479UTiSiXG484X1 1.0042e-22
C_0_111 WLL BL:n2d 1.0817e-22
C_0_112 WLR BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 2.9479e-19
C_0_113 WLR BL:LM00Cobalt2XG492UTiSiXG484X1 2.2605e-21
C_0_114 WLR BL:SiliconNXG479UTiSiXG484X1 1.0042e-22
C_0_115 WLR BL:n2d 1.0817e-22
C_0_116 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 3.9830e-21
C_0_117 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 9.9682e-22
C_0_118 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 BLB:SiliconNXG67UTiSiXG66X1 3.5558e-22
C_0_119 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 BLB:n3s 1.2414e-21
C_0_120 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.2877e-18
C_0_121 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 1.0329e-18
C_0_122 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.0361e-21
C_0_123 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 5.6036e-23
C_0_124 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 4.4015e-19
C_0_125 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 9.5890e-19
C_0_126 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 2.9480e-19
C_0_127 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 5.2997e-23
C_0_128 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 WL:n2g 8.1362e-20
C_0_129 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 WL:n3g 3.5277e-22
C_0_130 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 6.8861e-19
C_0_131 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 2.4797e-19
C_0_132 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 2.4765e-19
C_0_133 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 2.4757e-19
C_0_134 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:SDexcludeXG246UTiSiXG275X1 1.1882e-21
C_0_135 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:SDexcludeXG250UTiSiXG274X1 8.2234e-22
C_0_136 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:SiGeBXG261UTiSiXG275X1 4.1285e-22
C_0_137 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:SiGeBXG262UTiSiXG275X1 8.4850e-24
C_0_138 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:SiGeBXG265UTiSiXG275X1 8.4800e-24
C_0_139 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:SiGeBXG293UTiSiXG275X1 8.6180e-24
C_0_140 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:SiGeBXG297UTiSiXG275X1 8.4789e-24
C_0_141 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:SiliconNXG279UTiSiXG274X1 3.5526e-22
C_0_142 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:n1d 1.0168e-21
C_0_143 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:n2s 1.0168e-21
C_0_144 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:n4g 4.8860e-22
C_0_145 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:p1d 1.5841e-21
C_0_146 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ1:p2g 1.4532e-21
C_0_147 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.6309e-19
C_0_148 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 6.6422e-22
C_0_149 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 6.4114e-22
C_0_150 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 6.4104e-22
C_0_151 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:SDexcludeXG247UTiSiXG276X1 6.5195e-22
C_0_152 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:SDexcludeXG251UTiSiXG277X1 3.0618e-22
C_0_153 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:SiGeBXG266UTiSiXG276X1 2.3437e-23
C_0_154 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:SiGeBXG267UTiSiXG276X1 1.8183e-25
C_0_155 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:SiGeBXG270UTiSiXG276X1 1.7531e-25
C_0_156 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:SiliconNXG281UTiSiXG277X1 1.2462e-23
C_0_157 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:n1g 9.4069e-22
C_0_158 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:n3d 3.1849e-22
C_0_159 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:n4s 3.1849e-22
C_0_160 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:p1g 5.9618e-22
C_0_161 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 iQ2:p2s 6.7503e-22
C_0_162 BL:LM00Cobalt2XG492UTiSiXG484X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 9.9028e-22
C_0_163 BL:LM00Cobalt2XG492UTiSiXG484X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 2.3738e-23
C_0_164 BL:LM00Cobalt2XG492UTiSiXG484X1 BLB:SiliconNXG67UTiSiXG66X1 1.5274e-22
C_0_165 BL:LM00Cobalt2XG492UTiSiXG484X1 BLB:n3s 9.6216e-22
C_0_166 BL:LM00Cobalt2XG492UTiSiXG484X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.1448e-18
C_0_167 BL:LM00Cobalt2XG492UTiSiXG484X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 2.9087e-19
C_0_168 BL:LM00Cobalt2XG492UTiSiXG484X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 8.3276e-22
C_0_169 BL:LM00Cobalt2XG492UTiSiXG484X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 1.5724e-24
C_0_170 BL:LM00Cobalt2XG492UTiSiXG484X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 1.5009e-20
C_0_171 BL:LM00Cobalt2XG492UTiSiXG484X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.4632e-19
C_0_172 BL:LM00Cobalt2XG492UTiSiXG484X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 2.2605e-21
C_0_173 BL:LM00Cobalt2XG492UTiSiXG484X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 6.4356e-25
C_0_174 BL:LM00Cobalt2XG492UTiSiXG484X1 WL:n2g 8.2373e-20
C_0_175 BL:LM00Cobalt2XG492UTiSiXG484X1 WL:n3g 3.2878e-22
C_0_176 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 4.7588e-19
C_0_177 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 6.1592e-20
C_0_178 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 6.1249e-20
C_0_179 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 6.1211e-20
C_0_180 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:SDexcludeXG246UTiSiXG275X1 1.1614e-21
C_0_181 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:SDexcludeXG250UTiSiXG274X1 7.6302e-22
C_0_182 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:SiGeBXG261UTiSiXG275X1 3.9577e-22
C_0_183 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:SiGeBXG262UTiSiXG275X1 7.5029e-24
C_0_184 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:SiGeBXG265UTiSiXG275X1 7.5003e-24
C_0_185 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:SiGeBXG293UTiSiXG275X1 7.5875e-24
C_0_186 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:SiGeBXG297UTiSiXG275X1 7.5003e-24
C_0_187 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:SiliconNXG279UTiSiXG274X1 2.7750e-22
C_0_188 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:n1d 9.5041e-22
C_0_189 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:n2s 9.5041e-22
C_0_190 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:n4g 4.7551e-22
C_0_191 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:p1d 1.5422e-21
C_0_192 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ1:p2g 1.4093e-21
C_0_193 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 3.7777e-21
C_0_194 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.4193e-22
C_0_195 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.2481e-22
C_0_196 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.2480e-22
C_0_197 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:SDexcludeXG247UTiSiXG276X1 6.3394e-22
C_0_198 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:SDexcludeXG251UTiSiXG277X1 2.9768e-22
C_0_199 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:SiGeBXG266UTiSiXG276X1 1.7246e-23
C_0_200 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:SiGeBXG267UTiSiXG276X1 6.5324e-26
C_0_201 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:SiGeBXG270UTiSiXG276X1 6.0854e-26
C_0_202 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:SiliconNXG281UTiSiXG277X1 1.1967e-23
C_0_203 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:n1g 5.1822e-22
C_0_204 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:n3d 3.0953e-22
C_0_205 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:n4s 3.0953e-22
C_0_206 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:p1g 4.2345e-22
C_0_207 BL:LM00Cobalt2XG492UTiSiXG484X1 iQ2:p2s 6.5107e-22
C_0_208 BL:SiliconNXG479UTiSiXG484X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 3.6033e-22
C_0_209 BL:SiliconNXG479UTiSiXG484X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 1.5544e-22
C_0_210 BL:SiliconNXG479UTiSiXG484X1 BLB:SiliconNXG67UTiSiXG66X1 9.9713e-22
C_0_211 BL:SiliconNXG479UTiSiXG484X1 BLB:n3s 6.2399e-21
C_0_212 BL:SiliconNXG479UTiSiXG484X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.6767e-18
C_0_213 BL:SiliconNXG479UTiSiXG484X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 4.6953e-20
C_0_214 BL:SiliconNXG479UTiSiXG484X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 5.2793e-21
C_0_215 BL:SiliconNXG479UTiSiXG484X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 8.5939e-24
C_0_216 BL:SiliconNXG479UTiSiXG484X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 5.2245e-22
C_0_217 BL:SiliconNXG479UTiSiXG484X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 5.2140e-21
C_0_218 BL:SiliconNXG479UTiSiXG484X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 1.0048e-22
C_0_219 BL:SiliconNXG479UTiSiXG484X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 2.5223e-24
C_0_220 BL:SiliconNXG479UTiSiXG484X1 WL:n2g 1.7529e-21
C_0_221 BL:SiliconNXG479UTiSiXG484X1 WL:n3g 1.7062e-23
C_0_222 BL:SiliconNXG479UTiSiXG484X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 2.8052e-19
C_0_223 BL:SiliconNXG479UTiSiXG484X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 4.4627e-21
C_0_224 BL:SiliconNXG479UTiSiXG484X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 3.7218e-21
C_0_225 BL:SiliconNXG479UTiSiXG484X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 3.6989e-21
C_0_226 BL:SiliconNXG479UTiSiXG484X1 iQ1:SDexcludeXG246UTiSiXG275X1 6.6874e-21
C_0_227 BL:SiliconNXG479UTiSiXG484X1 iQ1:SDexcludeXG250UTiSiXG274X1 5.7905e-21
C_0_228 BL:SiliconNXG479UTiSiXG484X1 iQ1:SiGeBXG261UTiSiXG275X1 7.7444e-22
C_0_229 BL:SiliconNXG479UTiSiXG484X1 iQ1:SiGeBXG262UTiSiXG275X1 5.3122e-24
C_0_230 BL:SiliconNXG479UTiSiXG484X1 iQ1:SiGeBXG265UTiSiXG275X1 5.3031e-24
C_0_231 BL:SiliconNXG479UTiSiXG484X1 iQ1:SiGeBXG293UTiSiXG275X1 5.3618e-24
C_0_232 BL:SiliconNXG479UTiSiXG484X1 iQ1:SiGeBXG297UTiSiXG275X1 5.3030e-24
C_0_233 BL:SiliconNXG479UTiSiXG484X1 iQ1:SiliconNXG279UTiSiXG274X1 6.1591e-22
C_0_234 BL:SiliconNXG479UTiSiXG484X1 iQ1:n1d 6.3501e-21
C_0_235 BL:SiliconNXG479UTiSiXG484X1 iQ1:n2s 6.3501e-21
C_0_236 BL:SiliconNXG479UTiSiXG484X1 iQ1:n4g 2.2802e-23
C_0_237 BL:SiliconNXG479UTiSiXG484X1 iQ1:p1d 7.4512e-21
C_0_238 BL:SiliconNXG479UTiSiXG484X1 iQ1:p2g 5.7135e-23
C_0_239 BL:SiliconNXG479UTiSiXG484X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.9433e-20
C_0_240 BL:SiliconNXG479UTiSiXG484X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.1567e-22
C_0_241 BL:SiliconNXG479UTiSiXG484X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.6031e-23
C_0_242 BL:SiliconNXG479UTiSiXG484X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.6300e-23
C_0_243 BL:SiliconNXG479UTiSiXG484X1 iQ2:SDexcludeXG247UTiSiXG276X1 3.6265e-21
C_0_244 BL:SiliconNXG479UTiSiXG484X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.8030e-21
C_0_245 BL:SiliconNXG479UTiSiXG484X1 iQ2:SiGeBXG266UTiSiXG276X1 8.9677e-23
C_0_246 BL:SiliconNXG479UTiSiXG484X1 iQ2:SiGeBXG267UTiSiXG276X1 6.0343e-26
C_0_247 BL:SiliconNXG479UTiSiXG484X1 iQ2:SiGeBXG270UTiSiXG276X1 2.0652e-26
C_0_248 BL:SiliconNXG479UTiSiXG484X1 iQ2:SiliconNXG281UTiSiXG277X1 7.1335e-23
C_0_249 BL:SiliconNXG479UTiSiXG484X1 iQ2:n1g 2.7902e-23
C_0_250 BL:SiliconNXG479UTiSiXG484X1 iQ2:n3d 1.8737e-21
C_0_251 BL:SiliconNXG479UTiSiXG484X1 iQ2:n4s 1.8737e-21
C_0_252 BL:SiliconNXG479UTiSiXG484X1 iQ2:p1g 2.2097e-23
C_0_253 BL:SiliconNXG479UTiSiXG484X1 iQ2:p2s 3.7161e-21
C_0_254 BL:n2d BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 1.2597e-21
C_0_255 BL:n2d BLB:LM00Cobalt2XG63UTiSiXG66X1 9.7920e-22
C_0_256 BL:n2d BLB:SiliconNXG67UTiSiXG66X1 6.2386e-21
C_0_257 BL:n2d BLB:n3s 3.8869e-20
C_0_258 BL:n2d WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 3.5810e-18
C_0_259 BL:n2d WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 5.0665e-20
C_0_260 BL:n2d WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 3.2550e-20
C_0_261 BL:n2d WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 5.3538e-23
C_0_262 BL:n2d WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 5.5333e-22
C_0_263 BL:n2d WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 5.5181e-21
C_0_264 BL:n2d WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 1.0858e-22
C_0_265 BL:n2d WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 1.5619e-23
C_0_266 BL:n2d iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 5.5643e-19
C_0_267 BL:n2d iQ1:LM00Cobalt2XG280USiGeBXG261X1 6.4930e-21
C_0_268 BL:n2d iQ1:LM00Cobalt2XG280UTiSiXG274X1 4.4309e-21
C_0_269 BL:n2d iQ1:LM00Cobalt2XG280UTiSiXG275X1 4.3937e-21
C_0_270 BL:n2d iQ1:SDexcludeXG246UTiSiXG275X1 4.0825e-20
C_0_271 BL:n2d iQ1:SDexcludeXG250UTiSiXG274X1 8.0621e-20
C_0_272 BL:n2d iQ1:SiGeBXG261UTiSiXG275X1 2.1122e-21
C_0_273 BL:n2d iQ1:SiGeBXG262UTiSiXG275X1 6.4608e-24
C_0_274 BL:n2d iQ1:SiGeBXG265UTiSiXG275X1 6.4468e-24
C_0_275 BL:n2d iQ1:SiGeBXG293UTiSiXG275X1 6.6529e-24
C_0_276 BL:n2d iQ1:SiGeBXG297UTiSiXG275X1 6.4457e-24
C_0_277 BL:n2d iQ1:SiliconNXG279UTiSiXG274X1 2.4773e-21
C_0_278 BL:n2d iQ1:n1d 8.3011e-20
C_0_279 BL:n2d iQ1:n2s 8.3011e-20
C_0_280 BL:n2d iQ1:p1d 4.2924e-20
C_0_281 BL:n2d iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.3292e-19
C_0_282 BL:n2d iQ2:LM00Cobalt2XG117USiGeBXG266X1 5.9532e-22
C_0_283 BL:n2d iQ2:LM00Cobalt2XG117UTiSiXG276X1 6.5907e-23
C_0_284 BL:n2d iQ2:LM00Cobalt2XG117UTiSiXG277X1 6.7521e-23
C_0_285 BL:n2d iQ2:SDexcludeXG247UTiSiXG276X1 2.1221e-20
C_0_286 BL:n2d iQ2:SDexcludeXG251UTiSiXG277X1 1.0894e-20
C_0_287 BL:n2d iQ2:SiGeBXG266UTiSiXG276X1 5.2958e-22
C_0_288 BL:n2d iQ2:SiGeBXG267UTiSiXG276X1 2.2936e-25
C_0_289 BL:n2d iQ2:SiGeBXG270UTiSiXG276X1 8.5924e-26
C_0_290 BL:n2d iQ2:SiliconNXG281UTiSiXG277X1 4.2857e-22
C_0_291 BL:n2d iQ2:n3d 1.1319e-20
C_0_292 BL:n2d iQ2:n4s 1.1319e-20
C_0_293 BL:n2d iQ2:p2s 2.1750e-20
R_0_0 BLD BLU 2.3329e+01
R_0_1 BLD BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 2.2462e+01
R_0_2 BLU BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 6.0547e+02
R_0_3 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 BL:LM00Cobalt2XG492UTiSiXG484X1 1.1854e+02
R_0_4 BL:LM00Cobalt2XG492UTiSiXG484X1 BL:SiliconNXG479UTiSiXG484X1 4.0820e+02
R_0_5 BL:SiliconNXG479UTiSiXG484X1 BL:n2d 4.1726e+01

*|NET BLB 4.2935e-05PF
C_1_0 BLBD WLL 2.9322e-19
C_1_1 BLBD WLR 2.9322e-19
C_1_2 BLBD WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 2.4425e-22
C_1_3 BLBD WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 3.8791e-23
C_1_4 BLBD WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.4346e-19
C_1_5 BLBD WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 7.2302e-19
C_1_6 BLBD WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 2.9324e-19
C_1_7 BLBD WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 4.1297e-23
C_1_8 BLBD WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 4.0302e-19
C_1_9 BLBD WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 7.7377e-19
C_1_10 BLBD WL:n2g 4.1857e-23
C_1_11 BLBD WL:n3g 5.9913e-22
C_1_12 BLBD iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.7004e-19
C_1_13 BLBD iQ1:LM00Cobalt2XG280USiGeBXG261X1 5.3923e-22
C_1_14 BLBD iQ1:LM00Cobalt2XG280UTiSiXG274X1 5.3231e-22
C_1_15 BLBD iQ1:LM00Cobalt2XG280UTiSiXG275X1 5.3238e-22
C_1_16 BLBD iQ1:SDexcludeXG246UTiSiXG275X1 4.9149e-23
C_1_17 BLBD iQ1:SDexcludeXG250UTiSiXG274X1 2.3389e-23
C_1_18 BLBD iQ1:SiGeBXG261UTiSiXG275X1 7.0582e-24
C_1_19 BLBD iQ1:SiGeBXG262UTiSiXG275X1 1.0610e-25
C_1_20 BLBD iQ1:SiGeBXG265UTiSiXG275X1 1.0460e-25
C_1_21 BLBD iQ1:SiGeBXG293UTiSiXG275X1 1.0851e-25
C_1_22 BLBD iQ1:SiGeBXG297UTiSiXG275X1 1.0456e-25
C_1_23 BLBD iQ1:SiliconNXG279UTiSiXG274X1 1.1659e-24
C_1_24 BLBD iQ1:n1d 2.4495e-23
C_1_25 BLBD iQ1:n2s 2.4495e-23
C_1_26 BLBD iQ1:n4g 5.6050e-22
C_1_27 BLBD iQ1:p1d 5.5999e-23
C_1_28 BLBD iQ1:p2g 2.3459e-22
C_1_29 BLBD iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.1735e-19
C_1_30 BLBD iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.8563e-19
C_1_31 BLBD iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.8561e-19
C_1_32 BLBD iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.8565e-19
C_1_33 BLBD iQ2:SDexcludeXG247UTiSiXG276X1 7.9906e-23
C_1_34 BLBD iQ2:SDexcludeXG251UTiSiXG277X1 1.0223e-22
C_1_35 BLBD iQ2:SiGeBXG266UTiSiXG276X1 2.2835e-23
C_1_36 BLBD iQ2:SiGeBXG267UTiSiXG276X1 1.1526e-24
C_1_37 BLBD iQ2:SiGeBXG270UTiSiXG276X1 1.1491e-24
C_1_38 BLBD iQ2:SiliconNXG281UTiSiXG277X1 1.1269e-22
C_1_39 BLBD iQ2:n1g 3.5273e-23
C_1_40 BLBD iQ2:n3d 1.3327e-22
C_1_41 BLBD iQ2:n4s 1.3327e-22
C_1_42 BLBD iQ2:p1g 9.6230e-23
C_1_43 BLBD iQ2:p2s 1.0044e-22
C_1_44 BLBU WLL 2.9322e-19
C_1_45 BLBU WLR 2.9322e-19
C_1_46 BLBU WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 2.4425e-22
C_1_47 BLBU WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 3.8791e-23
C_1_48 BLBU WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.4346e-19
C_1_49 BLBU WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 7.2302e-19
C_1_50 BLBU WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 2.9324e-19
C_1_51 BLBU WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 4.1297e-23
C_1_52 BLBU WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 4.0302e-19
C_1_53 BLBU WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 7.7377e-19
C_1_54 BLBU WL:n2g 4.1857e-23
C_1_55 BLBU WL:n3g 5.9913e-22
C_1_56 BLBU iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.7004e-19
C_1_57 BLBU iQ1:LM00Cobalt2XG280USiGeBXG261X1 5.3923e-22
C_1_58 BLBU iQ1:LM00Cobalt2XG280UTiSiXG274X1 5.3231e-22
C_1_59 BLBU iQ1:LM00Cobalt2XG280UTiSiXG275X1 5.3238e-22
C_1_60 BLBU iQ1:SDexcludeXG246UTiSiXG275X1 4.9149e-23
C_1_61 BLBU iQ1:SDexcludeXG250UTiSiXG274X1 2.3389e-23
C_1_62 BLBU iQ1:SiGeBXG261UTiSiXG275X1 7.0582e-24
C_1_63 BLBU iQ1:SiGeBXG262UTiSiXG275X1 1.0610e-25
C_1_64 BLBU iQ1:SiGeBXG265UTiSiXG275X1 1.0460e-25
C_1_65 BLBU iQ1:SiGeBXG293UTiSiXG275X1 1.0851e-25
C_1_66 BLBU iQ1:SiGeBXG297UTiSiXG275X1 1.0456e-25
C_1_67 BLBU iQ1:SiliconNXG279UTiSiXG274X1 1.1659e-24
C_1_68 BLBU iQ1:n1d 2.4495e-23
C_1_69 BLBU iQ1:n2s 2.4495e-23
C_1_70 BLBU iQ1:n4g 5.6050e-22
C_1_71 BLBU iQ1:p1d 5.5999e-23
C_1_72 BLBU iQ1:p2g 2.3459e-22
C_1_73 BLBU iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.1735e-19
C_1_74 BLBU iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.8563e-19
C_1_75 BLBU iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.8561e-19
C_1_76 BLBU iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.8565e-19
C_1_77 BLBU iQ2:SDexcludeXG247UTiSiXG276X1 7.9906e-23
C_1_78 BLBU iQ2:SDexcludeXG251UTiSiXG277X1 1.0223e-22
C_1_79 BLBU iQ2:SiGeBXG266UTiSiXG276X1 2.2835e-23
C_1_80 BLBU iQ2:SiGeBXG267UTiSiXG276X1 1.1526e-24
C_1_81 BLBU iQ2:SiGeBXG270UTiSiXG276X1 1.1491e-24
C_1_82 BLBU iQ2:SiliconNXG281UTiSiXG277X1 1.1269e-22
C_1_83 BLBU iQ2:n1g 3.5273e-23
C_1_84 BLBU iQ2:n3d 1.3327e-22
C_1_85 BLBU iQ2:n4s 1.3327e-22
C_1_86 BLBU iQ2:p1g 9.6230e-23
C_1_87 BLBU iQ2:p2s 1.0044e-22
C_1_88 WLL BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 2.9509e-19
C_1_89 WLL BLB:LM00Cobalt2XG63UTiSiXG66X1 1.8690e-21
C_1_90 WLL BLB:SiliconNXG67UTiSiXG66X1 8.1868e-23
C_1_91 WLL BLB:n3s 8.8344e-23
C_1_92 WLR BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 2.9509e-19
C_1_93 WLR BLB:LM00Cobalt2XG63UTiSiXG66X1 1.8690e-21
C_1_94 WLR BLB:SiliconNXG67UTiSiXG66X1 8.1868e-23
C_1_95 WLR BLB:n3s 8.8344e-23
C_1_96 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.0247e-21
C_1_97 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 4.0358e-23
C_1_98 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.4474e-18
C_1_99 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 1.0814e-18
C_1_100 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 2.9511e-19
C_1_101 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 4.1962e-23
C_1_102 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 4.0969e-19
C_1_103 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 9.7735e-19
C_1_104 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 WL:n2g 3.6062e-22
C_1_105 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 WL:n3g 9.8469e-20
C_1_106 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.7370e-19
C_1_107 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 6.7675e-22
C_1_108 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 6.5321e-22
C_1_109 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 6.5325e-22
C_1_110 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:SDexcludeXG246UTiSiXG275X1 6.6033e-22
C_1_111 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:SDexcludeXG250UTiSiXG274X1 3.1087e-22
C_1_112 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:SiGeBXG261UTiSiXG275X1 2.3818e-23
C_1_113 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:SiGeBXG262UTiSiXG275X1 1.6372e-25
C_1_114 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:SiGeBXG265UTiSiXG275X1 1.6167e-25
C_1_115 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:SiGeBXG293UTiSiXG275X1 1.8188e-25
C_1_116 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:SiGeBXG297UTiSiXG275X1 1.6154e-25
C_1_117 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:SiliconNXG279UTiSiXG274X1 1.2853e-23
C_1_118 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:n1d 3.2350e-22
C_1_119 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:n2s 3.2350e-22
C_1_120 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:n4g 1.0547e-21
C_1_121 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:p1d 6.8383e-22
C_1_122 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ1:p2g 6.3939e-22
C_1_123 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 7.1113e-19
C_1_124 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.5050e-19
C_1_125 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.5012e-19
C_1_126 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.5018e-19
C_1_127 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:SDexcludeXG247UTiSiXG276X1 1.1912e-21
C_1_128 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:SDexcludeXG251UTiSiXG277X1 8.1337e-22
C_1_129 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:SiGeBXG266UTiSiXG276X1 4.0136e-22
C_1_130 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:SiGeBXG267UTiSiXG276X1 1.0836e-23
C_1_131 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:SiGeBXG270UTiSiXG276X1 1.0826e-23
C_1_132 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:SiliconNXG281UTiSiXG277X1 3.4291e-22
C_1_133 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:n1g 4.9582e-22
C_1_134 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:n3d 1.0026e-21
C_1_135 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:n4s 1.0026e-21
C_1_136 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:p1g 1.4551e-21
C_1_137 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 iQ2:p2s 1.5709e-21
C_1_138 BLB:LM00Cobalt2XG63UTiSiXG66X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 8.2248e-22
C_1_139 BLB:LM00Cobalt2XG63UTiSiXG66X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 1.6353e-24
C_1_140 BLB:LM00Cobalt2XG63UTiSiXG66X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.3123e-18
C_1_141 BLB:LM00Cobalt2XG63UTiSiXG66X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 3.5929e-19
C_1_142 BLB:LM00Cobalt2XG63UTiSiXG66X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 1.8691e-21
C_1_143 BLB:LM00Cobalt2XG63UTiSiXG66X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 6.8395e-25
C_1_144 BLB:LM00Cobalt2XG63UTiSiXG66X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 6.6748e-21
C_1_145 BLB:LM00Cobalt2XG63UTiSiXG66X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 2.0383e-19
C_1_146 BLB:LM00Cobalt2XG63UTiSiXG66X1 WL:n2g 3.3594e-22
C_1_147 BLB:LM00Cobalt2XG63UTiSiXG66X1 WL:n3g 9.9968e-20
C_1_148 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 3.8414e-21
C_1_149 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.3937e-22
C_1_150 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.2196e-22
C_1_151 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.2193e-22
C_1_152 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:SDexcludeXG246UTiSiXG275X1 6.4309e-22
C_1_153 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:SDexcludeXG250UTiSiXG274X1 3.0271e-22
C_1_154 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:SiGeBXG261UTiSiXG275X1 1.7557e-23
C_1_155 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:SiGeBXG262UTiSiXG275X1 5.8165e-26
C_1_156 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:SiGeBXG265UTiSiXG275X1 5.7601e-26
C_1_157 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:SiGeBXG293UTiSiXG275X1 7.4749e-26
C_1_158 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:SiGeBXG297UTiSiXG275X1 5.7506e-26
C_1_159 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:SiliconNXG279UTiSiXG274X1 1.2301e-23
C_1_160 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:n1d 3.1484e-22
C_1_161 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:n2s 3.1484e-22
C_1_162 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:n4g 5.2190e-22
C_1_163 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:p1d 6.6053e-22
C_1_164 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ1:p2g 4.2675e-22
C_1_165 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 5.0075e-19
C_1_166 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 6.5023e-20
C_1_167 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 6.4657e-20
C_1_168 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 6.4684e-20
C_1_169 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:SDexcludeXG247UTiSiXG276X1 1.1661e-21
C_1_170 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:SDexcludeXG251UTiSiXG277X1 7.4919e-22
C_1_171 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:SiGeBXG266UTiSiXG276X1 3.8527e-22
C_1_172 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:SiGeBXG267UTiSiXG276X1 9.7748e-24
C_1_173 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:SiGeBXG270UTiSiXG276X1 9.7674e-24
C_1_174 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:SiliconNXG281UTiSiXG277X1 2.3468e-22
C_1_175 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:n1g 4.8335e-22
C_1_176 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:n3d 9.1124e-22
C_1_177 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:n4s 9.1124e-22
C_1_178 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:p1g 1.4156e-21
C_1_179 BLB:LM00Cobalt2XG63UTiSiXG66X1 iQ2:p2s 1.5318e-21
C_1_180 BLB:SiliconNXG67UTiSiXG66X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 5.1218e-21
C_1_181 BLB:SiliconNXG67UTiSiXG66X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 7.9687e-24
C_1_182 BLB:SiliconNXG67UTiSiXG66X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.6718e-18
C_1_183 BLB:SiliconNXG67UTiSiXG66X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 4.8341e-20
C_1_184 BLB:SiliconNXG67UTiSiXG66X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 8.2048e-23
C_1_185 BLB:SiliconNXG67UTiSiXG66X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.8330e-24
C_1_186 BLB:SiliconNXG67UTiSiXG66X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 2.4012e-22
C_1_187 BLB:SiliconNXG67UTiSiXG66X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 7.4800e-21
C_1_188 BLB:SiliconNXG67UTiSiXG66X1 WL:n2g 1.7183e-23
C_1_189 BLB:SiliconNXG67UTiSiXG66X1 WL:n3g 2.0976e-21
C_1_190 BLB:SiliconNXG67UTiSiXG66X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.9308e-20
C_1_191 BLB:SiliconNXG67UTiSiXG66X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.1466e-22
C_1_192 BLB:SiliconNXG67UTiSiXG66X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 2.5187e-23
C_1_193 BLB:SiliconNXG67UTiSiXG66X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 2.4745e-23
C_1_194 BLB:SiliconNXG67UTiSiXG66X1 iQ1:SDexcludeXG246UTiSiXG275X1 3.6089e-21
C_1_195 BLB:SiliconNXG67UTiSiXG66X1 iQ1:SDexcludeXG250UTiSiXG274X1 1.7993e-21
C_1_196 BLB:SiliconNXG67UTiSiXG66X1 iQ1:SiGeBXG261UTiSiXG275X1 8.9946e-23
C_1_197 BLB:SiliconNXG67UTiSiXG66X1 iQ1:SiGeBXG262UTiSiXG275X1 1.8975e-26
C_1_198 BLB:SiliconNXG67UTiSiXG66X1 iQ1:SiGeBXG265UTiSiXG275X1 1.7206e-26
C_1_199 BLB:SiliconNXG67UTiSiXG66X1 iQ1:SiGeBXG293UTiSiXG275X1 1.1670e-25
C_1_200 BLB:SiliconNXG67UTiSiXG66X1 iQ1:SiGeBXG297UTiSiXG275X1 1.7272e-26
C_1_201 BLB:SiliconNXG67UTiSiXG66X1 iQ1:SiliconNXG279UTiSiXG274X1 7.1938e-23
C_1_202 BLB:SiliconNXG67UTiSiXG66X1 iQ1:n1d 1.8704e-21
C_1_203 BLB:SiliconNXG67UTiSiXG66X1 iQ1:n2s 1.8704e-21
C_1_204 BLB:SiliconNXG67UTiSiXG66X1 iQ1:n4g 2.7727e-23
C_1_205 BLB:SiliconNXG67UTiSiXG66X1 iQ1:p1d 3.6988e-21
C_1_206 BLB:SiliconNXG67UTiSiXG66X1 iQ1:p2g 2.1948e-23
C_1_207 BLB:SiliconNXG67UTiSiXG66X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.6502e-19
C_1_208 BLB:SiliconNXG67UTiSiXG66X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 3.7482e-21
C_1_209 BLB:SiliconNXG67UTiSiXG66X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 3.1188e-21
C_1_210 BLB:SiliconNXG67UTiSiXG66X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 3.1302e-21
C_1_211 BLB:SiliconNXG67UTiSiXG66X1 iQ2:SDexcludeXG247UTiSiXG276X1 6.5474e-21
C_1_212 BLB:SiliconNXG67UTiSiXG66X1 iQ2:SDexcludeXG251UTiSiXG277X1 5.6885e-21
C_1_213 BLB:SiliconNXG67UTiSiXG66X1 iQ2:SiGeBXG266UTiSiXG276X1 6.4034e-22
C_1_214 BLB:SiliconNXG67UTiSiXG66X1 iQ2:SiGeBXG267UTiSiXG276X1 5.4845e-24
C_1_215 BLB:SiliconNXG67UTiSiXG66X1 iQ2:SiGeBXG270UTiSiXG276X1 5.4695e-24
C_1_216 BLB:SiliconNXG67UTiSiXG66X1 iQ2:SiliconNXG281UTiSiXG277X1 4.8049e-22
C_1_217 BLB:SiliconNXG67UTiSiXG66X1 iQ2:n1g 2.2805e-23
C_1_218 BLB:SiliconNXG67UTiSiXG66X1 iQ2:n3d 6.1352e-21
C_1_219 BLB:SiliconNXG67UTiSiXG66X1 iQ2:n4s 6.1352e-21
C_1_220 BLB:SiliconNXG67UTiSiXG66X1 iQ2:p1g 5.6715e-23
C_1_221 BLB:SiliconNXG67UTiSiXG66X1 iQ2:p2s 7.1768e-21
C_1_222 BLB:n3s WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 3.1591e-20
C_1_223 BLB:n3s WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 4.9361e-23
C_1_224 BLB:n3s WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 3.5848e-18
C_1_225 BLB:n3s WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 5.1862e-20
C_1_226 BLB:n3s WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 8.9423e-23
C_1_227 BLB:n3s WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.0959e-23
C_1_228 BLB:n3s WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 2.5504e-22
C_1_229 BLB:n3s WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 7.8863e-21
C_1_230 BLB:n3s iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.3258e-19
C_1_231 BLB:n3s iQ1:LM00Cobalt2XG280USiGeBXG261X1 5.9798e-22
C_1_232 BLB:n3s iQ1:LM00Cobalt2XG280UTiSiXG274X1 6.8883e-23
C_1_233 BLB:n3s iQ1:LM00Cobalt2XG280UTiSiXG275X1 6.6245e-23
C_1_234 BLB:n3s iQ1:SDexcludeXG246UTiSiXG275X1 2.1136e-20
C_1_235 BLB:n3s iQ1:SDexcludeXG250UTiSiXG274X1 1.0877e-20
C_1_236 BLB:n3s iQ1:SiGeBXG261UTiSiXG275X1 5.3187e-22
C_1_237 BLB:n3s iQ1:SiGeBXG262UTiSiXG275X1 8.7502e-26
C_1_238 BLB:n3s iQ1:SiGeBXG265UTiSiXG275X1 6.8493e-26
C_1_239 BLB:n3s iQ1:SiGeBXG293UTiSiXG275X1 6.0622e-25
C_1_240 BLB:n3s iQ1:SiGeBXG297UTiSiXG275X1 6.7860e-26
C_1_241 BLB:n3s iQ1:SiliconNXG279UTiSiXG274X1 4.3281e-22
C_1_242 BLB:n3s iQ1:n1d 1.1305e-20
C_1_243 BLB:n3s iQ1:n2s 1.1305e-20
C_1_244 BLB:n3s iQ1:p1d 2.1668e-20
C_1_245 BLB:n3s iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 5.3227e-19
C_1_246 BLB:n3s iQ2:LM00Cobalt2XG117USiGeBXG266X1 5.5666e-21
C_1_247 BLB:n3s iQ2:LM00Cobalt2XG117UTiSiXG276X1 3.6971e-21
C_1_248 BLB:n3s iQ2:LM00Cobalt2XG117UTiSiXG277X1 3.7177e-21
C_1_249 BLB:n3s iQ2:SDexcludeXG247UTiSiXG276X1 4.0187e-20
C_1_250 BLB:n3s iQ2:SDexcludeXG251UTiSiXG277X1 8.0491e-20
C_1_251 BLB:n3s iQ2:SiGeBXG266UTiSiXG276X1 1.8828e-21
C_1_252 BLB:n3s iQ2:SiGeBXG267UTiSiXG276X1 6.7284e-24
C_1_253 BLB:n3s iQ2:SiGeBXG270UTiSiXG276X1 6.6891e-24
C_1_254 BLB:n3s iQ2:SiliconNXG281UTiSiXG277X1 2.2494e-21
C_1_255 BLB:n3s iQ2:n3d 8.2686e-20
C_1_256 BLB:n3s iQ2:n4s 8.2686e-20
C_1_257 BLB:n3s iQ2:p2s 4.2056e-20
R_1_0 BLBD BLBU 2.3270e+01
R_1_1 BLBD BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 5.0630e+02
R_1_2 BLBU BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 2.0125e+01
R_1_3 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 9.6740e+01
R_1_4 BLB:LM00Cobalt2XG63UTiSiXG66X1 BLB:SiliconNXG67UTiSiXG66X1 3.5634e+02
R_1_5 BLB:SiliconNXG67UTiSiXG66X1 BLB:n3s 4.1632e+01

*|NET VDD 6.6462e-05PF
C_2_0 BLBD VDD 1.0367e-18
C_2_1 BLBD VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 1.0478e-18
C_2_2 BLBD VDD:LM00Cobalt2XG47UTiSiXG48X1 1.1151e-20
C_2_3 BLBD VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 1.1517e-18
C_2_4 BLBD VDD:LM00Cobalt2XG494UTiSiXG487X1 1.1540e-19
C_2_5 BLBD VDD:SiGeBXG476UTiSiXG487X1 3.1844e-21
C_2_6 BLBD VDD:SiGeBXG49UTiSiXG48X1 1.4333e-21
C_2_7 BLBD VDD:p1s 1.7200e-21
C_2_8 BLBD VDD:p2d 3.3193e-21
C_2_9 BLBU VDD 1.0367e-18
C_2_10 BLBU VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 1.0478e-18
C_2_11 BLBU VDD:LM00Cobalt2XG47UTiSiXG48X1 1.1151e-20
C_2_12 BLBU VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 1.1517e-18
C_2_13 BLBU VDD:LM00Cobalt2XG494UTiSiXG487X1 1.1540e-19
C_2_14 BLBU VDD:SiGeBXG476UTiSiXG487X1 3.1844e-21
C_2_15 BLBU VDD:SiGeBXG49UTiSiXG48X1 1.4333e-21
C_2_16 BLBU VDD:p1s 1.7200e-21
C_2_17 BLBU VDD:p2d 3.3193e-21
C_2_18 BLD VDD 1.0369e-18
C_2_19 BLD VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 1.1550e-18
C_2_20 BLD VDD:LM00Cobalt2XG47UTiSiXG48X1 1.1850e-19
C_2_21 BLD VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 1.0479e-18
C_2_22 BLD VDD:LM00Cobalt2XG494UTiSiXG487X1 1.1152e-20
C_2_23 BLD VDD:SiGeBXG476UTiSiXG487X1 1.4672e-21
C_2_24 BLD VDD:SiGeBXG49UTiSiXG48X1 3.1779e-21
C_2_25 BLD VDD:p1s 3.2929e-21
C_2_26 BLD VDD:p2d 1.7627e-21
C_2_27 BLU VDD 1.0369e-18
C_2_28 BLU VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 1.1550e-18
C_2_29 BLU VDD:LM00Cobalt2XG47UTiSiXG48X1 1.1850e-19
C_2_30 BLU VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 1.0479e-18
C_2_31 BLU VDD:LM00Cobalt2XG494UTiSiXG487X1 1.1152e-20
C_2_32 BLU VDD:SiGeBXG476UTiSiXG487X1 1.4672e-21
C_2_33 BLU VDD:SiGeBXG49UTiSiXG48X1 3.1779e-21
C_2_34 BLU VDD:p1s 3.2929e-21
C_2_35 BLU VDD:p2d 1.7627e-21
C_2_36 VDD VSS 1.0710e-18
C_2_37 VDD VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 2.5290e-20
C_2_38 VDD VSS:LM00Cobalt2XG16UTiSiXG30X1 2.0484e-20
C_2_39 VDD VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 2.5308e-20
C_2_40 VDD VSS:LM00Cobalt2XG496UTiSiXG489X1 2.0369e-20
C_2_41 VDD VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 1.2772e-20
C_2_42 VDD VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 6.9648e-21
C_2_43 VDD VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 1.3203e-20
C_2_44 VDD VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 7.0640e-21
C_2_45 VDD VSS:SiliconNXG31UTiSiXG30X1 1.9408e-21
C_2_46 VDD VSS:SiliconNXG480UTiSiXG489X1 1.9355e-21
C_2_47 VDD VSS:n1s 2.2622e-21
C_2_48 VDD VSS:n4d 2.2651e-21
C_2_49 VDD WLL 5.2644e-19
C_2_50 VDD WLR 5.2644e-19
C_2_51 VDD BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 1.1112e-18
C_2_52 VDD BLB:LM00Cobalt2XG63UTiSiXG66X1 7.4838e-20
C_2_53 VDD BLB:SiliconNXG67UTiSiXG66X1 6.0995e-21
C_2_54 VDD BLB:n3s 7.1331e-21
C_2_55 VDD BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 1.1101e-18
C_2_56 VDD BL:LM00Cobalt2XG492UTiSiXG484X1 7.3614e-20
C_2_57 VDD BL:SiliconNXG479UTiSiXG484X1 6.2470e-21
C_2_58 VDD BL:n2d 7.3088e-21
C_2_59 VDD WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.4123e-20
C_2_60 VDD WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 3.6308e-21
C_2_61 VDD WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.3831e-20
C_2_62 VDD WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 5.0980e-21
C_2_63 VDD WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 5.2845e-19
C_2_64 VDD WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 4.4362e-21
C_2_65 VDD WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 5.2788e-19
C_2_66 VDD WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 5.4572e-21
C_2_67 VDD WL:n2g 4.8263e-22
C_2_68 VDD WL:n3g 4.3087e-22
C_2_69 VDD iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 4.3286e-19
C_2_70 VDD iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.7381e-19
C_2_71 VDD iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.7336e-19
C_2_72 VDD iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.7337e-19
C_2_73 VDD iQ1:SDexcludeXG246UTiSiXG275X1 2.5257e-22
C_2_74 VDD iQ1:SDexcludeXG250UTiSiXG274X1 9.7010e-23
C_2_75 VDD iQ1:SiGeBXG261UTiSiXG275X1 4.6682e-22
C_2_76 VDD iQ1:SiGeBXG262UTiSiXG275X1 1.0860e-23
C_2_77 VDD iQ1:SiGeBXG265UTiSiXG275X1 1.0876e-23
C_2_78 VDD iQ1:SiGeBXG293UTiSiXG275X1 1.0945e-23
C_2_79 VDD iQ1:SiGeBXG297UTiSiXG275X1 1.0850e-23
C_2_80 VDD iQ1:SiliconNXG279UTiSiXG274X1 1.3164e-23
C_2_81 VDD iQ1:n1d 1.0545e-22
C_2_82 VDD iQ1:n2s 1.0545e-22
C_2_83 VDD iQ1:n4g 1.7052e-22
C_2_84 VDD iQ1:p1d 6.9768e-22
C_2_85 VDD iQ1:p2g 8.4313e-22
C_2_86 VDD iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 4.2308e-19
C_2_87 VDD iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.7361e-19
C_2_88 VDD iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.7316e-19
C_2_89 VDD iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.7315e-19
C_2_90 VDD iQ2:SDexcludeXG247UTiSiXG276X1 2.5239e-22
C_2_91 VDD iQ2:SDexcludeXG251UTiSiXG277X1 9.5340e-23
C_2_92 VDD iQ2:SiGeBXG266UTiSiXG276X1 4.7190e-22
C_2_93 VDD iQ2:SiGeBXG267UTiSiXG276X1 1.1778e-23
C_2_94 VDD iQ2:SiGeBXG270UTiSiXG276X1 1.1757e-23
C_2_95 VDD iQ2:SiliconNXG281UTiSiXG277X1 1.0985e-23
C_2_96 VDD iQ2:n1g 1.6400e-22
C_2_97 VDD iQ2:n3d 1.0259e-22
C_2_98 VDD iQ2:n4s 1.0259e-22
C_2_99 VDD iQ2:p1g 7.4017e-22
C_2_100 VDD iQ2:p2s 7.0078e-22
C_2_101 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS 1.0837e-18
C_2_102 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 4.0441e-19
C_2_103 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS:LM00Cobalt2XG16UTiSiXG30X1 4.0987e-19
C_2_104 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 2.5328e-20
C_2_105 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS:LM00Cobalt2XG496UTiSiXG489X1 2.0391e-20
C_2_106 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 1.4224e-20
C_2_107 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 1.3057e-20
C_2_108 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 1.3204e-20
C_2_109 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 7.0645e-21
C_2_110 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS:SiliconNXG31UTiSiXG30X1 8.6194e-20
C_2_111 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS:SiliconNXG480UTiSiXG489X1 2.0755e-21
C_2_112 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS:n1s 8.1315e-20
C_2_113 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VSS:n4d 3.2799e-21
C_2_114 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 WLL 5.2700e-19
C_2_115 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 WLR 5.2700e-19
C_2_116 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 1.1679e-18
C_2_117 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 1.2117e-19
C_2_118 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 BLB:SiliconNXG67UTiSiXG66X1 2.1066e-20
C_2_119 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 BLB:n3s 2.7788e-20
C_2_120 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 1.2282e-18
C_2_121 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 BL:LM00Cobalt2XG492UTiSiXG484X1 7.3653e-20
C_2_122 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 BL:SiliconNXG479UTiSiXG484X1 6.4159e-21
C_2_123 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 BL:n2d 8.4004e-21
C_2_124 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.5198e-20
C_2_125 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 3.8098e-21
C_2_126 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 2.8345e-20
C_2_127 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 6.1897e-21
C_2_128 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 5.2901e-19
C_2_129 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 4.5958e-21
C_2_130 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 5.2848e-19
C_2_131 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 6.1246e-21
C_2_132 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 WL:n2g 8.9368e-22
C_2_133 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 WL:n3g 2.1157e-21
C_2_134 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 4.6043e-19
C_2_135 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.9661e-19
C_2_136 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.9606e-19
C_2_137 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.9607e-19
C_2_138 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:SDexcludeXG246UTiSiXG275X1 1.1087e-21
C_2_139 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:SDexcludeXG250UTiSiXG274X1 5.6114e-22
C_2_140 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:SiGeBXG261UTiSiXG275X1 5.6166e-22
C_2_141 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:SiGeBXG262UTiSiXG275X1 1.4011e-23
C_2_142 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:SiGeBXG265UTiSiXG275X1 1.4035e-23
C_2_143 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:SiGeBXG293UTiSiXG275X1 1.4105e-23
C_2_144 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:SiGeBXG297UTiSiXG275X1 1.3999e-23
C_2_145 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:SiliconNXG279UTiSiXG274X1 3.9089e-23
C_2_146 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:n1d 5.9191e-22
C_2_147 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:n2s 5.9191e-22
C_2_148 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:n4g 5.6367e-22
C_2_149 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:p1d 1.6424e-21
C_2_150 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ1:p2g 1.2323e-21
C_2_151 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.6134e-18
C_2_152 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.0182e-19
C_2_153 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.0127e-19
C_2_154 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.0126e-19
C_2_155 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:SDexcludeXG247UTiSiXG276X1 1.1472e-21
C_2_156 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:SDexcludeXG251UTiSiXG277X1 5.2292e-22
C_2_157 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:SiGeBXG266UTiSiXG276X1 5.7650e-22
C_2_158 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:SiGeBXG267UTiSiXG276X1 1.3247e-23
C_2_159 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:SiGeBXG270UTiSiXG276X1 1.3196e-23
C_2_160 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:SiliconNXG281UTiSiXG277X1 4.1605e-23
C_2_161 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:n1g 3.7418e-21
C_2_162 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:n3d 5.5813e-22
C_2_163 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:n4s 5.5813e-22
C_2_164 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:p1g 1.2541e-19
C_2_165 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 iQ2:p2s 1.6973e-21
C_2_166 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS 1.2833e-20
C_2_167 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 3.8352e-19
C_2_168 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS:LM00Cobalt2XG16UTiSiXG30X1 3.9439e-19
C_2_169 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 2.2174e-23
C_2_170 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS:LM00Cobalt2XG496UTiSiXG489X1 2.3818e-23
C_2_171 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 1.4636e-21
C_2_172 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 6.1556e-21
C_2_173 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 2.5373e-25
C_2_174 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 5.3145e-25
C_2_175 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS:SiliconNXG31UTiSiXG30X1 8.8997e-20
C_2_176 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS:SiliconNXG480UTiSiXG489X1 1.5101e-22
C_2_177 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS:n1s 8.4045e-20
C_2_178 VDD:LM00Cobalt2XG47UTiSiXG48X1 VSS:n4d 1.0940e-21
C_2_179 VDD:LM00Cobalt2XG47UTiSiXG48X1 WLL 5.5717e-22
C_2_180 VDD:LM00Cobalt2XG47UTiSiXG48X1 WLR 5.5717e-22
C_2_181 VDD:LM00Cobalt2XG47UTiSiXG48X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 5.7718e-20
C_2_182 VDD:LM00Cobalt2XG47UTiSiXG48X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 4.7292e-20
C_2_183 VDD:LM00Cobalt2XG47UTiSiXG48X1 BLB:SiliconNXG67UTiSiXG66X1 1.5550e-20
C_2_184 VDD:LM00Cobalt2XG47UTiSiXG48X1 BLB:n3s 2.1582e-20
C_2_185 VDD:LM00Cobalt2XG47UTiSiXG48X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 1.1854e-19
C_2_186 VDD:LM00Cobalt2XG47UTiSiXG48X1 BL:LM00Cobalt2XG492UTiSiXG484X1 4.0275e-23
C_2_187 VDD:LM00Cobalt2XG47UTiSiXG48X1 BL:SiliconNXG479UTiSiXG484X1 1.8255e-22
C_2_188 VDD:LM00Cobalt2XG47UTiSiXG48X1 BL:n2d 1.1808e-21
C_2_189 VDD:LM00Cobalt2XG47UTiSiXG48X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.1588e-21
C_2_190 VDD:LM00Cobalt2XG47UTiSiXG48X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 1.7945e-22
C_2_191 VDD:LM00Cobalt2XG47UTiSiXG48X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.5068e-20
C_2_192 VDD:LM00Cobalt2XG47UTiSiXG48X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 1.1116e-21
C_2_193 VDD:LM00Cobalt2XG47UTiSiXG48X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 5.5793e-22
C_2_194 VDD:LM00Cobalt2XG47UTiSiXG48X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.5997e-22
C_2_195 VDD:LM00Cobalt2XG47UTiSiXG48X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 6.0603e-22
C_2_196 VDD:LM00Cobalt2XG47UTiSiXG48X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 6.7773e-22
C_2_197 VDD:LM00Cobalt2XG47UTiSiXG48X1 WL:n2g 4.4503e-22
C_2_198 VDD:LM00Cobalt2XG47UTiSiXG48X1 WL:n3g 1.7799e-21
C_2_199 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 2.7827e-20
C_2_200 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 2.2800e-20
C_2_201 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 2.2709e-20
C_2_202 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 2.2710e-20
C_2_203 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:SDexcludeXG246UTiSiXG275X1 9.2574e-22
C_2_204 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:SDexcludeXG250UTiSiXG274X1 5.0325e-22
C_2_205 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:SiGeBXG261UTiSiXG275X1 9.6490e-23
C_2_206 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:SiGeBXG262UTiSiXG275X1 3.1531e-24
C_2_207 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:SiGeBXG265UTiSiXG275X1 3.1605e-24
C_2_208 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:SiGeBXG293UTiSiXG275X1 3.1628e-24
C_2_209 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:SiGeBXG297UTiSiXG275X1 3.1506e-24
C_2_210 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:SiliconNXG279UTiSiXG274X1 2.7856e-23
C_2_211 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:n1d 5.2743e-22
C_2_212 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:n2s 5.2743e-22
C_2_213 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:n4g 4.2324e-22
C_2_214 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:p1d 1.0159e-21
C_2_215 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ1:p2g 4.1872e-22
C_2_216 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.2128e-18
C_2_217 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.8348e-20
C_2_218 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.8244e-20
C_2_219 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.8243e-20
C_2_220 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:SDexcludeXG247UTiSiXG276X1 9.6142e-22
C_2_221 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:SDexcludeXG251UTiSiXG277X1 4.5878e-22
C_2_222 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:SiGeBXG266UTiSiXG276X1 1.0714e-22
C_2_223 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:SiGeBXG267UTiSiXG276X1 1.4823e-24
C_2_224 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:SiGeBXG270UTiSiXG276X1 1.4515e-24
C_2_225 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:SiliconNXG281UTiSiXG277X1 3.2371e-23
C_2_226 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:n1g 3.7766e-21
C_2_227 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:n3d 4.8841e-22
C_2_228 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:n4s 4.8841e-22
C_2_229 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:p1g 1.2749e-19
C_2_230 VDD:LM00Cobalt2XG47UTiSiXG48X1 iQ2:p2s 1.0657e-21
C_2_231 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS 1.0835e-18
C_2_232 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 2.5311e-20
C_2_233 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS:LM00Cobalt2XG16UTiSiXG30X1 2.0507e-20
C_2_234 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 3.8143e-19
C_2_235 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS:LM00Cobalt2XG496UTiSiXG489X1 3.8536e-19
C_2_236 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 1.2772e-20
C_2_237 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 6.9652e-21
C_2_238 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 1.4724e-20
C_2_239 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 1.3233e-20
C_2_240 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS:SiliconNXG31UTiSiXG30X1 2.0799e-21
C_2_241 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS:SiliconNXG480UTiSiXG489X1 8.5809e-20
C_2_242 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS:n1s 3.2690e-21
C_2_243 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VSS:n4d 8.2365e-20
C_2_244 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 WLL 5.2705e-19
C_2_245 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 WLR 5.2705e-19
C_2_246 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 1.2262e-18
C_2_247 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 7.4876e-20
C_2_248 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 BLB:SiliconNXG67UTiSiXG66X1 6.2664e-21
C_2_249 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 BLB:n3s 8.2130e-21
C_2_250 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 1.1654e-18
C_2_251 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 BL:LM00Cobalt2XG492UTiSiXG484X1 1.1855e-19
C_2_252 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 BL:SiliconNXG479UTiSiXG484X1 2.1276e-20
C_2_253 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 BL:n2d 2.8019e-20
C_2_254 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 2.8251e-20
C_2_255 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 4.5093e-21
C_2_256 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.4929e-20
C_2_257 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 5.2245e-21
C_2_258 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 5.2916e-19
C_2_259 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 4.9060e-21
C_2_260 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 5.2849e-19
C_2_261 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 5.5617e-21
C_2_262 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 WL:n2g 2.2452e-21
C_2_263 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 WL:n3g 8.3631e-22
C_2_264 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 2.3804e-18
C_2_265 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 2.0065e-19
C_2_266 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 2.0010e-19
C_2_267 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 2.0011e-19
C_2_268 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:SDexcludeXG246UTiSiXG275X1 1.1437e-21
C_2_269 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:SDexcludeXG250UTiSiXG274X1 5.2577e-22
C_2_270 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:SiGeBXG261UTiSiXG275X1 5.6985e-22
C_2_271 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:SiGeBXG262UTiSiXG275X1 1.2016e-23
C_2_272 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:SiGeBXG265UTiSiXG275X1 1.2033e-23
C_2_273 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:SiGeBXG293UTiSiXG275X1 1.2142e-23
C_2_274 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:SiGeBXG297UTiSiXG275X1 1.2006e-23
C_2_275 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:SiliconNXG279UTiSiXG274X1 4.8632e-23
C_2_276 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:n1d 5.6589e-22
C_2_277 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:n2s 5.6589e-22
C_2_278 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:n4g 3.9258e-21
C_2_279 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:p1d 1.6896e-21
C_2_280 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ1:p2g 1.0112e-19
C_2_281 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 4.4851e-19
C_2_282 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.9443e-19
C_2_283 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.9390e-19
C_2_284 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.9389e-19
C_2_285 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:SDexcludeXG247UTiSiXG276X1 1.1005e-21
C_2_286 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:SDexcludeXG251UTiSiXG277X1 5.5602e-22
C_2_287 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:SiGeBXG266UTiSiXG276X1 5.6173e-22
C_2_288 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:SiGeBXG267UTiSiXG276X1 1.4716e-23
C_2_289 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:SiGeBXG270UTiSiXG276X1 1.4682e-23
C_2_290 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:SiliconNXG281UTiSiXG277X1 3.7639e-23
C_2_291 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:n1g 5.5539e-22
C_2_292 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:n3d 5.8647e-22
C_2_293 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:n4s 5.8647e-22
C_2_294 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:p1g 1.1263e-21
C_2_295 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 iQ2:p2s 1.6329e-21
C_2_296 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS 1.2570e-20
C_2_297 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 2.2023e-23
C_2_298 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS:LM00Cobalt2XG16UTiSiXG30X1 2.3781e-23
C_2_299 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 3.6045e-19
C_2_300 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS:LM00Cobalt2XG496UTiSiXG489X1 3.6988e-19
C_2_301 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 2.9002e-25
C_2_302 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 4.1896e-25
C_2_303 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 1.5315e-21
C_2_304 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 6.2325e-21
C_2_305 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS:SiliconNXG31UTiSiXG30X1 1.4991e-22
C_2_306 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS:SiliconNXG480UTiSiXG489X1 8.8530e-20
C_2_307 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS:n1s 1.0848e-21
C_2_308 VDD:LM00Cobalt2XG494UTiSiXG487X1 VSS:n4d 8.5042e-20
C_2_309 VDD:LM00Cobalt2XG494UTiSiXG487X1 WLL 6.1306e-22
C_2_310 VDD:LM00Cobalt2XG494UTiSiXG487X1 WLR 6.1306e-22
C_2_311 VDD:LM00Cobalt2XG494UTiSiXG487X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 1.1544e-19
C_2_312 VDD:LM00Cobalt2XG494UTiSiXG487X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 4.0253e-23
C_2_313 VDD:LM00Cobalt2XG494UTiSiXG487X1 BLB:SiliconNXG67UTiSiXG66X1 1.8037e-22
C_2_314 VDD:LM00Cobalt2XG494UTiSiXG487X1 BLB:n3s 1.1674e-21
C_2_315 VDD:LM00Cobalt2XG494UTiSiXG487X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 5.6293e-20
C_2_316 VDD:LM00Cobalt2XG494UTiSiXG487X1 BL:LM00Cobalt2XG492UTiSiXG484X1 4.5859e-20
C_2_317 VDD:LM00Cobalt2XG494UTiSiXG487X1 BL:SiliconNXG479UTiSiXG484X1 1.5609e-20
C_2_318 VDD:LM00Cobalt2XG494UTiSiXG487X1 BL:n2d 2.1630e-20
C_2_319 VDD:LM00Cobalt2XG494UTiSiXG487X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.4655e-20
C_2_320 VDD:LM00Cobalt2XG494UTiSiXG487X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 8.9521e-22
C_2_321 VDD:LM00Cobalt2XG494UTiSiXG487X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.1828e-21
C_2_322 VDD:LM00Cobalt2XG494UTiSiXG487X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 1.2676e-22
C_2_323 VDD:LM00Cobalt2XG494UTiSiXG487X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 7.0936e-22
C_2_324 VDD:LM00Cobalt2XG494UTiSiXG487X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 4.7699e-22
C_2_325 VDD:LM00Cobalt2XG494UTiSiXG487X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 6.1381e-22
C_2_326 VDD:LM00Cobalt2XG494UTiSiXG487X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 1.0480e-22
C_2_327 VDD:LM00Cobalt2XG494UTiSiXG487X1 WL:n2g 1.8595e-21
C_2_328 VDD:LM00Cobalt2XG494UTiSiXG487X1 WL:n3g 4.3875e-22
C_2_329 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.9667e-18
C_2_330 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 2.6980e-20
C_2_331 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 2.6877e-20
C_2_332 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 2.6877e-20
C_2_333 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:SDexcludeXG246UTiSiXG275X1 9.5705e-22
C_2_334 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:SDexcludeXG250UTiSiXG274X1 4.5974e-22
C_2_335 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:SiGeBXG261UTiSiXG275X1 1.0572e-22
C_2_336 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:SiGeBXG262UTiSiXG275X1 1.1671e-24
C_2_337 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:SiGeBXG265UTiSiXG275X1 1.1680e-24
C_2_338 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:SiGeBXG293UTiSiXG275X1 1.2087e-24
C_2_339 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:SiGeBXG297UTiSiXG275X1 1.1669e-24
C_2_340 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:SiliconNXG279UTiSiXG274X1 3.7393e-23
C_2_341 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:n1d 4.9323e-22
C_2_342 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:n2s 4.9323e-22
C_2_343 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:n4g 3.9512e-21
C_2_344 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:p1d 1.0604e-21
C_2_345 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ1:p2g 1.0223e-19
C_2_346 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.5678e-20
C_2_347 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.0830e-20
C_2_348 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.0744e-20
C_2_349 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.0743e-20
C_2_350 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:SDexcludeXG247UTiSiXG276X1 9.1678e-22
C_2_351 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:SDexcludeXG251UTiSiXG277X1 4.9929e-22
C_2_352 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:SiGeBXG266UTiSiXG276X1 9.1445e-23
C_2_353 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:SiGeBXG267UTiSiXG276X1 2.9400e-24
C_2_354 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:SiGeBXG270UTiSiXG276X1 2.9269e-24
C_2_355 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:SiliconNXG281UTiSiXG277X1 2.8568e-23
C_2_356 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:n1g 4.2112e-22
C_2_357 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:n3d 5.2434e-22
C_2_358 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:n4s 5.2434e-22
C_2_359 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:p1g 4.1526e-22
C_2_360 VDD:LM00Cobalt2XG494UTiSiXG487X1 iQ2:p2s 1.0024e-21
C_2_361 VDD:SiGeBXG476UTiSiXG487X1 VSS 7.0687e-22
C_2_362 VDD:SiGeBXG476UTiSiXG487X1 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 1.1222e-22
C_2_363 VDD:SiGeBXG476UTiSiXG487X1 VSS:LM00Cobalt2XG16UTiSiXG30X1 1.2282e-22
C_2_364 VDD:SiGeBXG476UTiSiXG487X1 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 4.7562e-20
C_2_365 VDD:SiGeBXG476UTiSiXG487X1 VSS:LM00Cobalt2XG496UTiSiXG489X1 5.7009e-20
C_2_366 VDD:SiGeBXG476UTiSiXG487X1 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 1.8656e-25
C_2_367 VDD:SiGeBXG476UTiSiXG487X1 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 1.4093e-24
C_2_368 VDD:SiGeBXG476UTiSiXG487X1 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 9.4234e-23
C_2_369 VDD:SiGeBXG476UTiSiXG487X1 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 5.9097e-22
C_2_370 VDD:SiGeBXG476UTiSiXG487X1 VSS:SiliconNXG31UTiSiXG30X1 8.2435e-22
C_2_371 VDD:SiGeBXG476UTiSiXG487X1 VSS:SiliconNXG480UTiSiXG489X1 1.4776e-19
C_2_372 VDD:SiGeBXG476UTiSiXG487X1 VSS:n1s 5.9067e-21
C_2_373 VDD:SiGeBXG476UTiSiXG487X1 VSS:n4d 2.0432e-19
C_2_374 VDD:SiGeBXG476UTiSiXG487X1 WLL 3.3985e-23
C_2_375 VDD:SiGeBXG476UTiSiXG487X1 WLR 3.3985e-23
C_2_376 VDD:SiGeBXG476UTiSiXG487X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 3.3345e-21
C_2_377 VDD:SiGeBXG476UTiSiXG487X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 1.5833e-22
C_2_378 VDD:SiGeBXG476UTiSiXG487X1 BLB:SiliconNXG67UTiSiXG66X1 1.0596e-21
C_2_379 VDD:SiGeBXG476UTiSiXG487X1 BLB:n3s 6.9166e-21
C_2_380 VDD:SiGeBXG476UTiSiXG487X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 1.6511e-20
C_2_381 VDD:SiGeBXG476UTiSiXG487X1 BL:LM00Cobalt2XG492UTiSiXG484X1 1.5500e-20
C_2_382 VDD:SiGeBXG476UTiSiXG487X1 BL:SiliconNXG479UTiSiXG484X1 1.6384e-20
C_2_383 VDD:SiGeBXG476UTiSiXG487X1 BL:n2d 3.3643e-20
C_2_384 VDD:SiGeBXG476UTiSiXG487X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.9818e-20
C_2_385 VDD:SiGeBXG476UTiSiXG487X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 2.8811e-22
C_2_386 VDD:SiGeBXG476UTiSiXG487X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 6.7565e-21
C_2_387 VDD:SiGeBXG476UTiSiXG487X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 1.1191e-23
C_2_388 VDD:SiGeBXG476UTiSiXG487X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 4.9581e-23
C_2_389 VDD:SiGeBXG476UTiSiXG487X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.0652e-22
C_2_390 VDD:SiGeBXG476UTiSiXG487X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 3.4085e-23
C_2_391 VDD:SiGeBXG476UTiSiXG487X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 4.4187e-24
C_2_392 VDD:SiGeBXG476UTiSiXG487X1 WL:n2g 9.6860e-23
C_2_393 VDD:SiGeBXG476UTiSiXG487X1 WL:n3g 3.3308e-23
C_2_394 VDD:SiGeBXG476UTiSiXG487X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.6841e-18
C_2_395 VDD:SiGeBXG476UTiSiXG487X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.9234e-21
C_2_396 VDD:SiGeBXG476UTiSiXG487X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.7752e-21
C_2_397 VDD:SiGeBXG476UTiSiXG487X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.7739e-21
C_2_398 VDD:SiGeBXG476UTiSiXG487X1 iQ1:SDexcludeXG246UTiSiXG275X1 4.9021e-21
C_2_399 VDD:SiGeBXG476UTiSiXG487X1 iQ1:SDexcludeXG250UTiSiXG274X1 2.1748e-21
C_2_400 VDD:SiGeBXG476UTiSiXG487X1 iQ1:SiGeBXG261UTiSiXG275X1 1.4997e-22
C_2_401 VDD:SiGeBXG476UTiSiXG487X1 iQ1:SiGeBXG262UTiSiXG275X1 2.5575e-25
C_2_402 VDD:SiGeBXG476UTiSiXG487X1 iQ1:SiGeBXG265UTiSiXG275X1 2.5317e-25
C_2_403 VDD:SiGeBXG476UTiSiXG487X1 iQ1:SiGeBXG293UTiSiXG275X1 2.6278e-25
C_2_404 VDD:SiGeBXG476UTiSiXG487X1 iQ1:SiGeBXG297UTiSiXG275X1 2.5291e-25
C_2_405 VDD:SiGeBXG476UTiSiXG487X1 iQ1:SiliconNXG279UTiSiXG274X1 1.0771e-22
C_2_406 VDD:SiGeBXG476UTiSiXG487X1 iQ1:n1d 2.2794e-21
C_2_407 VDD:SiGeBXG476UTiSiXG487X1 iQ1:n2s 2.2794e-21
C_2_408 VDD:SiGeBXG476UTiSiXG487X1 iQ1:n4g 1.9593e-22
C_2_409 VDD:SiGeBXG476UTiSiXG487X1 iQ1:p1d 5.0516e-21
C_2_410 VDD:SiGeBXG476UTiSiXG487X1 iQ1:p2g 1.9561e-21
C_2_411 VDD:SiGeBXG476UTiSiXG487X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.5097e-20
C_2_412 VDD:SiGeBXG476UTiSiXG487X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.5344e-22
C_2_413 VDD:SiGeBXG476UTiSiXG487X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.1808e-22
C_2_414 VDD:SiGeBXG476UTiSiXG487X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.1926e-22
C_2_415 VDD:SiGeBXG476UTiSiXG487X1 iQ2:SDexcludeXG247UTiSiXG276X1 6.0732e-21
C_2_416 VDD:SiGeBXG476UTiSiXG487X1 iQ2:SDexcludeXG251UTiSiXG277X1 3.1193e-21
C_2_417 VDD:SiGeBXG476UTiSiXG487X1 iQ2:SiGeBXG266UTiSiXG276X1 1.3544e-22
C_2_418 VDD:SiGeBXG476UTiSiXG487X1 iQ2:SiGeBXG267UTiSiXG276X1 5.1143e-26
C_2_419 VDD:SiGeBXG476UTiSiXG487X1 iQ2:SiGeBXG270UTiSiXG276X1 4.0025e-26
C_2_420 VDD:SiGeBXG476UTiSiXG487X1 iQ2:SiliconNXG281UTiSiXG277X1 1.3717e-22
C_2_421 VDD:SiGeBXG476UTiSiXG487X1 iQ2:n1g 2.9732e-23
C_2_422 VDD:SiGeBXG476UTiSiXG487X1 iQ2:n3d 3.2540e-21
C_2_423 VDD:SiGeBXG476UTiSiXG487X1 iQ2:n4s 3.2540e-21
C_2_424 VDD:SiGeBXG476UTiSiXG487X1 iQ2:p1g 2.9161e-23
C_2_425 VDD:SiGeBXG476UTiSiXG487X1 iQ2:p2s 6.2086e-21
C_2_426 VDD:SiGeBXG49UTiSiXG48X1 VSS 7.1658e-22
C_2_427 VDD:SiGeBXG49UTiSiXG48X1 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 4.7463e-20
C_2_428 VDD:SiGeBXG49UTiSiXG48X1 VSS:LM00Cobalt2XG16UTiSiXG30X1 5.7335e-20
C_2_429 VDD:SiGeBXG49UTiSiXG48X1 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 1.1100e-22
C_2_430 VDD:SiGeBXG49UTiSiXG48X1 VSS:LM00Cobalt2XG496UTiSiXG489X1 1.2142e-22
C_2_431 VDD:SiGeBXG49UTiSiXG48X1 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 9.1341e-23
C_2_432 VDD:SiGeBXG49UTiSiXG48X1 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 5.8869e-22
C_2_433 VDD:SiGeBXG49UTiSiXG48X1 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 1.5472e-25
C_2_434 VDD:SiGeBXG49UTiSiXG48X1 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 1.4371e-24
C_2_435 VDD:SiGeBXG49UTiSiXG48X1 VSS:SiliconNXG31UTiSiXG30X1 1.4653e-19
C_2_436 VDD:SiGeBXG49UTiSiXG48X1 VSS:SiliconNXG480UTiSiXG489X1 8.2257e-22
C_2_437 VDD:SiGeBXG49UTiSiXG48X1 VSS:n1s 2.0247e-19
C_2_438 VDD:SiGeBXG49UTiSiXG48X1 VSS:n4d 5.9007e-21
C_2_439 VDD:SiGeBXG49UTiSiXG48X1 WLL 3.0683e-23
C_2_440 VDD:SiGeBXG49UTiSiXG48X1 WLR 3.0683e-23
C_2_441 VDD:SiGeBXG49UTiSiXG48X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 1.6649e-20
C_2_442 VDD:SiGeBXG49UTiSiXG48X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 1.5667e-20
C_2_443 VDD:SiGeBXG49UTiSiXG48X1 BLB:SiliconNXG67UTiSiXG66X1 1.6173e-20
C_2_444 VDD:SiGeBXG49UTiSiXG48X1 BLB:n3s 3.3313e-20
C_2_445 VDD:SiGeBXG49UTiSiXG48X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 3.3257e-21
C_2_446 VDD:SiGeBXG49UTiSiXG48X1 BL:LM00Cobalt2XG492UTiSiXG484X1 1.5612e-22
C_2_447 VDD:SiGeBXG49UTiSiXG48X1 BL:SiliconNXG479UTiSiXG484X1 1.0631e-21
C_2_448 VDD:SiGeBXG49UTiSiXG48X1 BL:n2d 6.9369e-21
C_2_449 VDD:SiGeBXG49UTiSiXG48X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 6.5745e-21
C_2_450 VDD:SiGeBXG49UTiSiXG48X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 1.1284e-23
C_2_451 VDD:SiGeBXG49UTiSiXG48X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 2.0480e-20
C_2_452 VDD:SiGeBXG49UTiSiXG48X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 3.2972e-22
C_2_453 VDD:SiGeBXG49UTiSiXG48X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 3.0899e-23
C_2_454 VDD:SiGeBXG49UTiSiXG48X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 4.5358e-24
C_2_455 VDD:SiGeBXG49UTiSiXG48X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 3.7774e-23
C_2_456 VDD:SiGeBXG49UTiSiXG48X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 1.5133e-22
C_2_457 VDD:SiGeBXG49UTiSiXG48X1 WL:n2g 3.3979e-23
C_2_458 VDD:SiGeBXG49UTiSiXG48X1 WL:n3g 9.5050e-23
C_2_459 VDD:SiGeBXG49UTiSiXG48X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.5134e-20
C_2_460 VDD:SiGeBXG49UTiSiXG48X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 2.1952e-22
C_2_461 VDD:SiGeBXG49UTiSiXG48X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 8.5201e-23
C_2_462 VDD:SiGeBXG49UTiSiXG48X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 8.3432e-23
C_2_463 VDD:SiGeBXG49UTiSiXG48X1 iQ1:SDexcludeXG246UTiSiXG275X1 6.0731e-21
C_2_464 VDD:SiGeBXG49UTiSiXG48X1 iQ1:SDexcludeXG250UTiSiXG274X1 3.1230e-21
C_2_465 VDD:SiGeBXG49UTiSiXG48X1 iQ1:SiGeBXG261UTiSiXG275X1 1.3615e-22
C_2_466 VDD:SiGeBXG49UTiSiXG48X1 iQ1:SiGeBXG262UTiSiXG275X1 4.0775e-26
C_2_467 VDD:SiGeBXG49UTiSiXG48X1 iQ1:SiGeBXG265UTiSiXG275X1 3.1084e-26
C_2_468 VDD:SiGeBXG49UTiSiXG48X1 iQ1:SiGeBXG293UTiSiXG275X1 1.0635e-25
C_2_469 VDD:SiGeBXG49UTiSiXG48X1 iQ1:SiGeBXG297UTiSiXG275X1 3.0983e-26
C_2_470 VDD:SiGeBXG49UTiSiXG48X1 iQ1:SiliconNXG279UTiSiXG274X1 1.3777e-22
C_2_471 VDD:SiGeBXG49UTiSiXG48X1 iQ1:n1d 3.2572e-21
C_2_472 VDD:SiGeBXG49UTiSiXG48X1 iQ1:n2s 3.2572e-21
C_2_473 VDD:SiGeBXG49UTiSiXG48X1 iQ1:n4g 3.0094e-23
C_2_474 VDD:SiGeBXG49UTiSiXG48X1 iQ1:p1d 6.2092e-21
C_2_475 VDD:SiGeBXG49UTiSiXG48X1 iQ1:p2g 2.9523e-23
C_2_476 VDD:SiGeBXG49UTiSiXG48X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.6251e-18
C_2_477 VDD:SiGeBXG49UTiSiXG48X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.8418e-21
C_2_478 VDD:SiGeBXG49UTiSiXG48X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.6991e-21
C_2_479 VDD:SiGeBXG49UTiSiXG48X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.6999e-21
C_2_480 VDD:SiGeBXG49UTiSiXG48X1 iQ2:SDexcludeXG247UTiSiXG276X1 4.8769e-21
C_2_481 VDD:SiGeBXG49UTiSiXG48X1 iQ2:SDexcludeXG251UTiSiXG277X1 2.1575e-21
C_2_482 VDD:SiGeBXG49UTiSiXG48X1 iQ2:SiGeBXG266UTiSiXG276X1 1.4325e-22
C_2_483 VDD:SiGeBXG49UTiSiXG48X1 iQ2:SiGeBXG267UTiSiXG276X1 3.1746e-25
C_2_484 VDD:SiGeBXG49UTiSiXG48X1 iQ2:SiGeBXG270UTiSiXG276X1 2.9319e-25
C_2_485 VDD:SiGeBXG49UTiSiXG48X1 iQ2:SiliconNXG281UTiSiXG277X1 1.0068e-22
C_2_486 VDD:SiGeBXG49UTiSiXG48X1 iQ2:n1g 1.9877e-22
C_2_487 VDD:SiGeBXG49UTiSiXG48X1 iQ2:n3d 2.2561e-21
C_2_488 VDD:SiGeBXG49UTiSiXG48X1 iQ2:n4s 2.2561e-21
C_2_489 VDD:SiGeBXG49UTiSiXG48X1 iQ2:p1g 2.8202e-21
C_2_490 VDD:SiGeBXG49UTiSiXG48X1 iQ2:p2s 5.0196e-21
C_2_491 VDD:p1s VSS 7.7677e-22
C_2_492 VDD:p1s VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 5.2401e-20
C_2_493 VDD:p1s VSS:LM00Cobalt2XG16UTiSiXG30X1 6.2960e-20
C_2_494 VDD:p1s VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 7.6488e-22
C_2_495 VDD:p1s VSS:LM00Cobalt2XG496UTiSiXG489X1 8.3723e-22
C_2_496 VDD:p1s VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 9.5513e-23
C_2_497 VDD:p1s VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 6.4603e-22
C_2_498 VDD:p1s VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 1.0701e-24
C_2_499 VDD:p1s VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 9.7733e-24
C_2_500 VDD:p1s VSS:SiliconNXG31UTiSiXG30X1 2.0724e-19
C_2_501 VDD:p1s VSS:SiliconNXG480UTiSiXG489X1 5.6535e-21
C_2_502 VDD:p1s VSS:n1s 4.3839e-19
C_2_503 VDD:p1s VSS:n4d 4.0221e-20
C_2_504 VDD:p1s WLL 3.3337e-23
C_2_505 VDD:p1s WLR 3.3337e-23
C_2_506 VDD:p1s BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 2.2306e-20
C_2_507 VDD:p1s BLB:LM00Cobalt2XG63UTiSiXG66X1 2.1282e-20
C_2_508 VDD:p1s BLB:SiliconNXG67UTiSiXG66X1 3.3891e-20
C_2_509 VDD:p1s BLB:n3s 1.0356e-19
C_2_510 VDD:p1s BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 4.3707e-21
C_2_511 VDD:p1s BL:LM00Cobalt2XG492UTiSiXG484X1 1.1380e-21
C_2_512 VDD:p1s BL:SiliconNXG479UTiSiXG484X1 7.7325e-21
C_2_513 VDD:p1s BL:n2d 5.0516e-20
C_2_514 VDD:p1s WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 4.9086e-20
C_2_515 VDD:p1s WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 6.3705e-23
C_2_516 VDD:p1s WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 7.1034e-20
C_2_517 VDD:p1s WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 5.0405e-22
C_2_518 VDD:p1s WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 3.4643e-23
C_2_519 VDD:p1s WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.6110e-23
C_2_520 VDD:p1s WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 4.2316e-23
C_2_521 VDD:p1s WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 2.1060e-22
C_2_522 VDD:p1s iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.1157e-19
C_2_523 VDD:p1s iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.6478e-21
C_2_524 VDD:p1s iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.8523e-22
C_2_525 VDD:p1s iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.7800e-22
C_2_526 VDD:p1s iQ1:SDexcludeXG246UTiSiXG275X1 1.4438e-19
C_2_527 VDD:p1s iQ1:SDexcludeXG250UTiSiXG274X1 2.3189e-20
C_2_528 VDD:p1s iQ1:SiGeBXG261UTiSiXG275X1 1.4703e-21
C_2_529 VDD:p1s iQ1:SiGeBXG262UTiSiXG275X1 3.0726e-25
C_2_530 VDD:p1s iQ1:SiGeBXG265UTiSiXG275X1 2.5130e-25
C_2_531 VDD:p1s iQ1:SiGeBXG293UTiSiXG275X1 6.5353e-25
C_2_532 VDD:p1s iQ1:SiGeBXG297UTiSiXG275X1 2.5063e-25
C_2_533 VDD:p1s iQ1:SiliconNXG279UTiSiXG274X1 1.0218e-21
C_2_534 VDD:p1s iQ1:n1d 2.4196e-20
C_2_535 VDD:p1s iQ1:n2s 2.4196e-20
C_2_536 VDD:p1s iQ1:p1d 1.4585e-19
C_2_537 VDD:p1s iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 3.6698e-18
C_2_538 VDD:p1s iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.8964e-21
C_2_539 VDD:p1s iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.9822e-21
C_2_540 VDD:p1s iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.9847e-21
C_2_541 VDD:p1s iQ2:SDexcludeXG247UTiSiXG276X1 3.3450e-20
C_2_542 VDD:p1s iQ2:SDexcludeXG251UTiSiXG277X1 1.3445e-20
C_2_543 VDD:p1s iQ2:SiGeBXG266UTiSiXG276X1 9.1523e-22
C_2_544 VDD:p1s iQ2:SiGeBXG267UTiSiXG276X1 6.8147e-25
C_2_545 VDD:p1s iQ2:SiGeBXG270UTiSiXG276X1 5.0202e-25
C_2_546 VDD:p1s iQ2:SiliconNXG281UTiSiXG277X1 5.6639e-22
C_2_547 VDD:p1s iQ2:n3d 1.4006e-20
C_2_548 VDD:p1s iQ2:n4s 1.4006e-20
C_2_549 VDD:p1s iQ2:p2s 3.4364e-20
C_2_550 VDD:p2d VSS 7.6880e-22
C_2_551 VDD:p2d VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 7.7268e-22
C_2_552 VDD:p2d VSS:LM00Cobalt2XG16UTiSiXG30X1 8.4624e-22
C_2_553 VDD:p2d VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 5.2639e-20
C_2_554 VDD:p2d VSS:LM00Cobalt2XG496UTiSiXG489X1 6.2784e-20
C_2_555 VDD:p2d VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 1.1372e-24
C_2_556 VDD:p2d VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 9.5585e-24
C_2_557 VDD:p2d VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 9.8604e-23
C_2_558 VDD:p2d VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 6.5071e-22
C_2_559 VDD:p2d VSS:SiliconNXG31UTiSiXG30X1 5.6616e-21
C_2_560 VDD:p2d VSS:SiliconNXG480UTiSiXG489X1 2.0866e-19
C_2_561 VDD:p2d VSS:n1s 4.0230e-20
C_2_562 VDD:p2d VSS:n4d 4.4056e-19
C_2_563 VDD:p2d WLL 3.6826e-23
C_2_564 VDD:p2d WLR 3.6826e-23
C_2_565 VDD:p2d BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 4.4122e-21
C_2_566 VDD:p2d BLB:LM00Cobalt2XG63UTiSiXG66X1 1.1531e-21
C_2_567 VDD:p2d BLB:SiliconNXG67UTiSiXG66X1 7.6987e-21
C_2_568 VDD:p2d BLB:n3s 5.0309e-20
C_2_569 VDD:p2d BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 2.2083e-20
C_2_570 VDD:p2d BL:LM00Cobalt2XG492UTiSiXG484X1 2.1020e-20
C_2_571 VDD:p2d BL:SiliconNXG479UTiSiXG484X1 3.4209e-20
C_2_572 VDD:p2d BL:n2d 1.0426e-19
C_2_573 VDD:p2d WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 6.8752e-20
C_2_574 VDD:p2d WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 4.4657e-22
C_2_575 VDD:p2d WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 5.0531e-20
C_2_576 VDD:p2d WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 6.7858e-23
C_2_577 VDD:p2d WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 5.6961e-23
C_2_578 VDD:p2d WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.4772e-22
C_2_579 VDD:p2d WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 3.7327e-23
C_2_580 VDD:p2d WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 2.0850e-23
C_2_581 VDD:p2d iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 3.7499e-18
C_2_582 VDD:p2d iQ1:LM00Cobalt2XG280USiGeBXG261X1 3.0129e-21
C_2_583 VDD:p2d iQ1:LM00Cobalt2XG280UTiSiXG274X1 2.0838e-21
C_2_584 VDD:p2d iQ1:LM00Cobalt2XG280UTiSiXG275X1 2.0795e-21
C_2_585 VDD:p2d iQ1:SDexcludeXG246UTiSiXG275X1 3.3621e-20
C_2_586 VDD:p2d iQ1:SDexcludeXG250UTiSiXG274X1 1.3520e-20
C_2_587 VDD:p2d iQ1:SiGeBXG261UTiSiXG275X1 9.3422e-22
C_2_588 VDD:p2d iQ1:SiGeBXG262UTiSiXG275X1 4.5684e-25
C_2_589 VDD:p2d iQ1:SiGeBXG265UTiSiXG275X1 4.2544e-25
C_2_590 VDD:p2d iQ1:SiGeBXG293UTiSiXG275X1 6.8273e-25
C_2_591 VDD:p2d iQ1:SiGeBXG297UTiSiXG275X1 4.2419e-25
C_2_592 VDD:p2d iQ1:SiliconNXG279UTiSiXG274X1 5.8627e-22
C_2_593 VDD:p2d iQ1:n1d 1.4097e-20
C_2_594 VDD:p2d iQ1:n2s 1.4097e-20
C_2_595 VDD:p2d iQ1:p1d 3.4554e-20
C_2_596 VDD:p2d iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.1086e-19
C_2_597 VDD:p2d iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.6881e-21
C_2_598 VDD:p2d iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.2812e-22
C_2_599 VDD:p2d iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.3272e-22
C_2_600 VDD:p2d iQ2:SDexcludeXG247UTiSiXG276X1 1.4448e-19
C_2_601 VDD:p2d iQ2:SDexcludeXG251UTiSiXG277X1 2.3136e-20
C_2_602 VDD:p2d iQ2:SiGeBXG266UTiSiXG276X1 1.4605e-21
C_2_603 VDD:p2d iQ2:SiGeBXG267UTiSiXG276X1 3.9236e-25
C_2_604 VDD:p2d iQ2:SiGeBXG270UTiSiXG276X1 3.0090e-25
C_2_605 VDD:p2d iQ2:SiliconNXG281UTiSiXG277X1 1.0099e-21
C_2_606 VDD:p2d iQ2:n3d 2.4137e-20
C_2_607 VDD:p2d iQ2:n4s 2.4137e-20
C_2_608 VDD:p2d iQ2:p2s 1.4594e-19
R_2_0 VDD VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 6.2512e+01
R_2_1 VDD VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 7.2590e+01
R_2_2 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VDD:LM00Cobalt2XG47UTiSiXG48X1 9.4527e+01
R_2_3 VDD:LM00Cobalt2XG47ULM40Cobalt5XG54X1 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 1.9862e+03
R_2_4 VDD:LM00Cobalt2XG47UTiSiXG48X1 VDD:SiGeBXG49UTiSiXG48X1 2.3022e+02
R_2_5 VDD:LM00Cobalt2XG494ULM40Cobalt5XG54X1 VDD:LM00Cobalt2XG494UTiSiXG487X1 1.1591e+02
R_2_6 VDD:LM00Cobalt2XG494UTiSiXG487X1 VDD:SiGeBXG476UTiSiXG487X1 2.5247e+02
R_2_7 VDD:SiGeBXG476UTiSiXG487X1 VDD:p2d 3.7297e+01
R_2_8 VDD:SiGeBXG49UTiSiXG48X1 VDD:p1s 3.7215e+01

*|NET VSS 6.3777e-05PF
C_3_0 BLBD VSS 6.5655e-19
C_3_1 BLBD VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 4.1570e-22
C_3_2 BLBD VSS:LM00Cobalt2XG16UTiSiXG30X1 3.7272e-22
C_3_3 BLBD VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 7.9632e-19
C_3_4 BLBD VSS:LM00Cobalt2XG496UTiSiXG489X1 2.5238e-19
C_3_5 BLBD VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 1.3960e-22
C_3_6 BLBD VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 7.3977e-23
C_3_7 BLBD VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 1.8940e-19
C_3_8 BLBD VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 6.1287e-19
C_3_9 BLBD VSS:SiliconNXG31UTiSiXG30X1 1.3963e-22
C_3_10 BLBD VSS:SiliconNXG480UTiSiXG489X1 6.1850e-21
C_3_11 BLBD VSS:n1s 2.4408e-22
C_3_12 BLBD VSS:n4d 6.1932e-21
C_3_13 BLBU VSS 6.5655e-19
C_3_14 BLBU VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 4.1570e-22
C_3_15 BLBU VSS:LM00Cobalt2XG16UTiSiXG30X1 3.7272e-22
C_3_16 BLBU VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 7.9632e-19
C_3_17 BLBU VSS:LM00Cobalt2XG496UTiSiXG489X1 2.5238e-19
C_3_18 BLBU VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 1.3960e-22
C_3_19 BLBU VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 7.3977e-23
C_3_20 BLBU VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 1.8940e-19
C_3_21 BLBU VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 6.1287e-19
C_3_22 BLBU VSS:SiliconNXG31UTiSiXG30X1 1.3963e-22
C_3_23 BLBU VSS:SiliconNXG480UTiSiXG489X1 6.1850e-21
C_3_24 BLBU VSS:n1s 2.4408e-22
C_3_25 BLBU VSS:n4d 6.1932e-21
C_3_26 BLD VSS 6.6051e-19
C_3_27 BLD VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 7.3988e-19
C_3_28 BLD VSS:LM00Cobalt2XG16UTiSiXG30X1 2.6068e-19
C_3_29 BLD VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 4.1730e-22
C_3_30 BLD VSS:LM00Cobalt2XG496UTiSiXG489X1 3.7244e-22
C_3_31 BLD VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 1.9227e-19
C_3_32 BLD VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 5.5136e-19
C_3_33 BLD VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 1.4868e-22
C_3_34 BLD VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 7.5773e-23
C_3_35 BLD VSS:SiliconNXG31UTiSiXG30X1 6.0481e-21
C_3_36 BLD VSS:SiliconNXG480UTiSiXG489X1 1.4025e-22
C_3_37 BLD VSS:n1s 5.9981e-21
C_3_38 BLD VSS:n4d 2.4708e-22
C_3_39 BLU VSS 6.6051e-19
C_3_40 BLU VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 7.3988e-19
C_3_41 BLU VSS:LM00Cobalt2XG16UTiSiXG30X1 2.6068e-19
C_3_42 BLU VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 4.1730e-22
C_3_43 BLU VSS:LM00Cobalt2XG496UTiSiXG489X1 3.7244e-22
C_3_44 BLU VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 1.9227e-19
C_3_45 BLU VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 5.5136e-19
C_3_46 BLU VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 1.4868e-22
C_3_47 BLU VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 7.5773e-23
C_3_48 BLU VSS:SiliconNXG31UTiSiXG30X1 6.0481e-21
C_3_49 BLU VSS:SiliconNXG480UTiSiXG489X1 1.4025e-22
C_3_50 BLU VSS:n1s 5.9981e-21
C_3_51 BLU VSS:n4d 2.4708e-22
C_3_52 VSS WLL 3.1048e-18
C_3_53 VSS WLR 3.1048e-18
C_3_54 VSS BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 6.9786e-19
C_3_55 VSS BLB:LM00Cobalt2XG63UTiSiXG66X1 4.1395e-20
C_3_56 VSS BLB:SiliconNXG67UTiSiXG66X1 1.9456e-21
C_3_57 VSS BLB:n3s 2.0956e-21
C_3_58 VSS BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 7.0476e-19
C_3_59 VSS BL:LM00Cobalt2XG492UTiSiXG484X1 4.4336e-20
C_3_60 VSS BL:SiliconNXG479UTiSiXG484X1 2.1034e-21
C_3_61 VSS BL:n2d 2.2648e-21
C_3_62 VSS WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 4.4486e-21
C_3_63 VSS WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 4.4338e-20
C_3_64 VSS WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 3.5278e-21
C_3_65 VSS WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 9.0058e-20
C_3_66 VSS WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 3.2762e-18
C_3_67 VSS WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 2.1301e-19
C_3_68 VSS WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 3.2501e-18
C_3_69 VSS WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 2.3325e-19
C_3_70 VSS WL:n2g 8.7517e-23
C_3_71 VSS WL:n3g 7.7139e-23
C_3_72 VSS iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 4.7311e-21
C_3_73 VSS iQ1:LM00Cobalt2XG280USiGeBXG261X1 5.5311e-22
C_3_74 VSS iQ1:LM00Cobalt2XG280UTiSiXG274X1 5.5182e-22
C_3_75 VSS iQ1:LM00Cobalt2XG280UTiSiXG275X1 5.5173e-22
C_3_76 VSS iQ1:SDexcludeXG246UTiSiXG275X1 2.0160e-23
C_3_77 VSS iQ1:SDexcludeXG250UTiSiXG274X1 1.1953e-23
C_3_78 VSS iQ1:SiGeBXG261UTiSiXG275X1 1.4170e-24
C_3_79 VSS iQ1:SiGeBXG262UTiSiXG275X1 1.7664e-26
C_3_80 VSS iQ1:SiGeBXG265UTiSiXG275X1 1.7390e-26
C_3_81 VSS iQ1:SiGeBXG293UTiSiXG275X1 6.2569e-25
C_3_82 VSS iQ1:SiGeBXG297UTiSiXG275X1 1.8252e-26
C_3_83 VSS iQ1:SiliconNXG279UTiSiXG274X1 1.0941e-24
C_3_84 VSS iQ1:n1d 1.2835e-23
C_3_85 VSS iQ1:n2s 1.2835e-23
C_3_86 VSS iQ1:n4g 2.2773e-23
C_3_87 VSS iQ1:p1d 2.1542e-23
C_3_88 VSS iQ1:p2g 3.2585e-23
C_3_89 VSS iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 4.6340e-21
C_3_90 VSS iQ2:LM00Cobalt2XG117USiGeBXG266X1 5.4331e-22
C_3_91 VSS iQ2:LM00Cobalt2XG117UTiSiXG276X1 5.4205e-22
C_3_92 VSS iQ2:LM00Cobalt2XG117UTiSiXG277X1 5.4212e-22
C_3_93 VSS iQ2:SDexcludeXG247UTiSiXG276X1 2.0015e-23
C_3_94 VSS iQ2:SDexcludeXG251UTiSiXG277X1 1.1742e-23
C_3_95 VSS iQ2:SiGeBXG266UTiSiXG276X1 1.3065e-24
C_3_96 VSS iQ2:SiGeBXG267UTiSiXG276X1 2.0132e-26
C_3_97 VSS iQ2:SiGeBXG270UTiSiXG276X1 1.9428e-26
C_3_98 VSS iQ2:SiliconNXG281UTiSiXG277X1 1.0006e-24
C_3_99 VSS iQ2:n1g 2.2506e-23
C_3_100 VSS iQ2:n3d 1.2566e-23
C_3_101 VSS iQ2:n4s 1.2566e-23
C_3_102 VSS iQ2:p1g 3.2429e-23
C_3_103 VSS iQ2:p2s 2.1283e-23
C_3_104 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 WLL 1.5944e-20
C_3_105 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 WLR 1.5944e-20
C_3_106 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 1.7399e-21
C_3_107 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 1.3490e-21
C_3_108 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 BLB:SiliconNXG67UTiSiXG66X1 7.3162e-22
C_3_109 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 BLB:n3s 1.7391e-21
C_3_110 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 7.3997e-19
C_3_111 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 BL:LM00Cobalt2XG492UTiSiXG484X1 9.0553e-23
C_3_112 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 BL:SiliconNXG479UTiSiXG484X1 1.5401e-22
C_3_113 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 BL:n2d 1.0406e-21
C_3_114 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 7.3679e-21
C_3_115 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 2.7213e-19
C_3_116 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.1984e-21
C_3_117 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 3.8927e-23
C_3_118 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 1.9838e-20
C_3_119 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 2.7310e-19
C_3_120 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 1.5946e-20
C_3_121 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 2.5630e-23
C_3_122 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 WL:n2g 5.3503e-22
C_3_123 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 WL:n3g 3.3470e-22
C_3_124 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 5.1706e-20
C_3_125 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 4.9432e-20
C_3_126 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 5.0019e-20
C_3_127 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 4.9415e-20
C_3_128 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:SDexcludeXG246UTiSiXG275X1 6.3139e-22
C_3_129 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:SDexcludeXG250UTiSiXG274X1 1.5255e-21
C_3_130 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:SiGeBXG261UTiSiXG275X1 1.7539e-23
C_3_131 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:SiGeBXG262UTiSiXG275X1 1.6921e-25
C_3_132 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:SiGeBXG265UTiSiXG275X1 1.6182e-25
C_3_133 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:SiGeBXG293UTiSiXG275X1 2.3098e-25
C_3_134 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:SiGeBXG297UTiSiXG275X1 1.6147e-25
C_3_135 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:SiliconNXG279UTiSiXG274X1 2.3540e-21
C_3_136 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:n1d 2.6706e-21
C_3_137 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:n2s 2.6706e-21
C_3_138 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:n4g 2.4208e-22
C_3_139 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:p1d 6.4860e-22
C_3_140 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ1:p2g 2.4336e-22
C_3_141 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.9482e-18
C_3_142 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 3.0979e-22
C_3_143 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.9762e-22
C_3_144 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.9766e-22
C_3_145 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:SDexcludeXG247UTiSiXG276X1 4.1712e-22
C_3_146 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:SDexcludeXG251UTiSiXG277X1 2.1229e-22
C_3_147 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:SiGeBXG266UTiSiXG276X1 1.2234e-23
C_3_148 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:SiGeBXG267UTiSiXG276X1 4.2983e-26
C_3_149 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:SiGeBXG270UTiSiXG276X1 3.1819e-26
C_3_150 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:SiliconNXG281UTiSiXG277X1 8.8752e-24
C_3_151 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:n1g 1.3495e-19
C_3_152 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:n3d 2.2103e-22
C_3_153 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:n4s 2.2103e-22
C_3_154 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:p1g 3.0554e-21
C_3_155 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 iQ2:p2s 4.2929e-22
C_3_156 VSS:LM00Cobalt2XG16UTiSiXG30X1 WLL 2.6725e-22
C_3_157 VSS:LM00Cobalt2XG16UTiSiXG30X1 WLR 2.6725e-22
C_3_158 VSS:LM00Cobalt2XG16UTiSiXG30X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 1.7094e-21
C_3_159 VSS:LM00Cobalt2XG16UTiSiXG30X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 1.3625e-21
C_3_160 VSS:LM00Cobalt2XG16UTiSiXG30X1 BLB:SiliconNXG67UTiSiXG66X1 7.8253e-22
C_3_161 VSS:LM00Cobalt2XG16UTiSiXG30X1 BLB:n3s 1.8879e-21
C_3_162 VSS:LM00Cobalt2XG16UTiSiXG30X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 2.6074e-19
C_3_163 VSS:LM00Cobalt2XG16UTiSiXG30X1 BL:LM00Cobalt2XG492UTiSiXG484X1 5.6979e-23
C_3_164 VSS:LM00Cobalt2XG16UTiSiXG30X1 BL:SiliconNXG479UTiSiXG484X1 1.6731e-22
C_3_165 VSS:LM00Cobalt2XG16UTiSiXG30X1 BL:n2d 1.1350e-21
C_3_166 VSS:LM00Cobalt2XG16UTiSiXG30X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 5.6811e-21
C_3_167 VSS:LM00Cobalt2XG16UTiSiXG30X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 1.3119e-20
C_3_168 VSS:LM00Cobalt2XG16UTiSiXG30X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.2982e-21
C_3_169 VSS:LM00Cobalt2XG16UTiSiXG30X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 3.7610e-23
C_3_170 VSS:LM00Cobalt2XG16UTiSiXG30X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 2.7056e-22
C_3_171 VSS:LM00Cobalt2XG16UTiSiXG30X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.1509e-20
C_3_172 VSS:LM00Cobalt2XG16UTiSiXG30X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 2.6942e-22
C_3_173 VSS:LM00Cobalt2XG16UTiSiXG30X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 2.3708e-23
C_3_174 VSS:LM00Cobalt2XG16UTiSiXG30X1 WL:n2g 5.7345e-22
C_3_175 VSS:LM00Cobalt2XG16UTiSiXG30X1 WL:n3g 3.6659e-22
C_3_176 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 4.0590e-20
C_3_177 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 3.8107e-20
C_3_178 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 3.8663e-20
C_3_179 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 3.8088e-20
C_3_180 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:SDexcludeXG246UTiSiXG275X1 6.9391e-22
C_3_181 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:SDexcludeXG250UTiSiXG274X1 1.5511e-21
C_3_182 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:SiGeBXG261UTiSiXG275X1 1.9031e-23
C_3_183 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:SiGeBXG262UTiSiXG275X1 1.6588e-25
C_3_184 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:SiGeBXG265UTiSiXG275X1 1.5853e-25
C_3_185 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:SiGeBXG293UTiSiXG275X1 1.6776e-25
C_3_186 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:SiGeBXG297UTiSiXG275X1 1.5814e-25
C_3_187 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:SiliconNXG279UTiSiXG274X1 2.2884e-21
C_3_188 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:n1d 2.6891e-21
C_3_189 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:n2s 2.6891e-21
C_3_190 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:n4g 2.6529e-22
C_3_191 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:p1d 7.1262e-22
C_3_192 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ1:p2g 2.6677e-22
C_3_193 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.9403e-18
C_3_194 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 3.0861e-22
C_3_195 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.9538e-22
C_3_196 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.9542e-22
C_3_197 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:SDexcludeXG247UTiSiXG276X1 4.5826e-22
C_3_198 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:SDexcludeXG251UTiSiXG277X1 2.3279e-22
C_3_199 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:SiGeBXG266UTiSiXG276X1 1.3291e-23
C_3_200 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:SiGeBXG267UTiSiXG276X1 4.2864e-26
C_3_201 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:SiGeBXG270UTiSiXG276X1 3.2135e-26
C_3_202 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:SiliconNXG281UTiSiXG277X1 9.7201e-24
C_3_203 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:n1g 1.3805e-19
C_3_204 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:n3d 2.4237e-22
C_3_205 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:n4s 2.4237e-22
C_3_206 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:p1g 3.4898e-21
C_3_207 VSS:LM00Cobalt2XG16UTiSiXG30X1 iQ2:p2s 4.7149e-22
C_3_208 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 WLL 2.4093e-20
C_3_209 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 WLR 2.4093e-20
C_3_210 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 7.9645e-19
C_3_211 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 1.3417e-22
C_3_212 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 BLB:SiliconNXG67UTiSiXG66X1 1.5221e-22
C_3_213 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 BLB:n3s 1.0258e-21
C_3_214 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 1.7059e-21
C_3_215 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 BL:LM00Cobalt2XG492UTiSiXG484X1 1.3130e-21
C_3_216 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 BL:SiliconNXG479UTiSiXG484X1 7.3138e-22
C_3_217 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 BL:n2d 1.7343e-21
C_3_218 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.1567e-21
C_3_219 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 3.0655e-23
C_3_220 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 9.5741e-21
C_3_221 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 2.6826e-19
C_3_222 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 2.4097e-20
C_3_223 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.8483e-23
C_3_224 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 3.1893e-20
C_3_225 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 2.7158e-19
C_3_226 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 WL:n2g 3.3728e-22
C_3_227 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 WL:n3g 5.2447e-22
C_3_228 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.7340e-18
C_3_229 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 3.1471e-22
C_3_230 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 3.0241e-22
C_3_231 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 3.0234e-22
C_3_232 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:SDexcludeXG246UTiSiXG275X1 4.1457e-22
C_3_233 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:SDexcludeXG250UTiSiXG274X1 2.1118e-22
C_3_234 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:SiGeBXG261UTiSiXG275X1 1.2423e-23
C_3_235 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:SiGeBXG262UTiSiXG275X1 3.3724e-26
C_3_236 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:SiGeBXG265UTiSiXG275X1 2.6731e-26
C_3_237 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:SiGeBXG293UTiSiXG275X1 3.5519e-26
C_3_238 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:SiGeBXG297UTiSiXG275X1 2.6822e-26
C_3_239 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:SiliconNXG279UTiSiXG274X1 9.1040e-24
C_3_240 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:n1d 2.2008e-22
C_3_241 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:n2s 2.2008e-22
C_3_242 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:n4g 1.1008e-19
C_3_243 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:p1d 4.2694e-22
C_3_244 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ1:p2g 3.1973e-21
C_3_245 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 5.2510e-20
C_3_246 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 5.0261e-20
C_3_247 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 5.0244e-20
C_3_248 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 5.0761e-20
C_3_249 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:SDexcludeXG247UTiSiXG276X1 6.2496e-22
C_3_250 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.4075e-21
C_3_251 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:SiGeBXG266UTiSiXG276X1 1.7333e-23
C_3_252 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:SiGeBXG267UTiSiXG276X1 1.7232e-25
C_3_253 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:SiGeBXG270UTiSiXG276X1 1.6378e-25
C_3_254 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:SiliconNXG281UTiSiXG277X1 2.4657e-21
C_3_255 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:n1g 2.4026e-22
C_3_256 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:n3d 2.8395e-21
C_3_257 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:n4s 2.8395e-21
C_3_258 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:p1g 2.4133e-22
C_3_259 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 iQ2:p2s 6.4197e-22
C_3_260 VSS:LM00Cobalt2XG496UTiSiXG489X1 WLL 2.9414e-22
C_3_261 VSS:LM00Cobalt2XG496UTiSiXG489X1 WLR 2.9414e-22
C_3_262 VSS:LM00Cobalt2XG496UTiSiXG489X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 2.5244e-19
C_3_263 VSS:LM00Cobalt2XG496UTiSiXG489X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 5.9657e-23
C_3_264 VSS:LM00Cobalt2XG496UTiSiXG489X1 BLB:SiliconNXG67UTiSiXG66X1 1.6468e-22
C_3_265 VSS:LM00Cobalt2XG496UTiSiXG489X1 BLB:n3s 1.1176e-21
C_3_266 VSS:LM00Cobalt2XG496UTiSiXG489X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 1.6702e-21
C_3_267 VSS:LM00Cobalt2XG496UTiSiXG489X1 BL:LM00Cobalt2XG492UTiSiXG484X1 1.3233e-21
C_3_268 VSS:LM00Cobalt2XG496UTiSiXG489X1 BL:SiliconNXG479UTiSiXG484X1 7.8087e-22
C_3_269 VSS:LM00Cobalt2XG496UTiSiXG489X1 BL:n2d 1.8801e-21
C_3_270 VSS:LM00Cobalt2XG496UTiSiXG489X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.2507e-21
C_3_271 VSS:LM00Cobalt2XG496UTiSiXG489X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 2.9877e-23
C_3_272 VSS:LM00Cobalt2XG496UTiSiXG489X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 6.0131e-21
C_3_273 VSS:LM00Cobalt2XG496UTiSiXG489X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 8.2124e-21
C_3_274 VSS:LM00Cobalt2XG496UTiSiXG489X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 2.9816e-22
C_3_275 VSS:LM00Cobalt2XG496UTiSiXG489X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.6880e-23
C_3_276 VSS:LM00Cobalt2XG496UTiSiXG489X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 2.9730e-22
C_3_277 VSS:LM00Cobalt2XG496UTiSiXG489X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 6.4331e-21
C_3_278 VSS:LM00Cobalt2XG496UTiSiXG489X1 WL:n2g 3.6898e-22
C_3_279 VSS:LM00Cobalt2XG496UTiSiXG489X1 WL:n3g 5.5939e-22
C_3_280 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.7089e-18
C_3_281 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 3.1277e-22
C_3_282 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 2.9942e-22
C_3_283 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 2.9934e-22
C_3_284 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:SDexcludeXG246UTiSiXG275X1 4.5508e-22
C_3_285 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:SDexcludeXG250UTiSiXG274X1 2.3141e-22
C_3_286 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:SiGeBXG261UTiSiXG275X1 1.3484e-23
C_3_287 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:SiGeBXG262UTiSiXG275X1 3.3875e-26
C_3_288 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:SiGeBXG265UTiSiXG275X1 2.6941e-26
C_3_289 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:SiGeBXG293UTiSiXG275X1 3.2213e-26
C_3_290 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:SiGeBXG297UTiSiXG275X1 2.6955e-26
C_3_291 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:SiliconNXG279UTiSiXG274X1 9.9567e-24
C_3_292 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:n1d 2.4115e-22
C_3_293 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:n2s 2.4115e-22
C_3_294 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:n4g 1.1242e-19
C_3_295 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:p1d 4.6851e-22
C_3_296 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ1:p2g 3.6082e-21
C_3_297 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 3.6286e-20
C_3_298 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 3.3835e-20
C_3_299 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 3.3817e-20
C_3_300 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 3.4285e-20
C_3_301 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:SDexcludeXG247UTiSiXG276X1 6.8632e-22
C_3_302 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.4097e-21
C_3_303 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:SiGeBXG266UTiSiXG276X1 1.8774e-23
C_3_304 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:SiGeBXG267UTiSiXG276X1 1.6710e-25
C_3_305 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:SiGeBXG270UTiSiXG276X1 1.5895e-25
C_3_306 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:SiliconNXG281UTiSiXG277X1 2.3258e-21
C_3_307 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:n1g 2.6313e-22
C_3_308 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:n3d 2.7989e-21
C_3_309 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:n4s 2.7989e-21
C_3_310 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:p1g 2.6436e-22
C_3_311 VSS:LM00Cobalt2XG496UTiSiXG489X1 iQ2:p2s 7.0478e-22
C_3_312 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 WLL 2.9446e-19
C_3_313 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 WLR 2.9446e-19
C_3_314 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 1.8740e-22
C_3_315 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 4.8212e-23
C_3_316 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 BLB:SiliconNXG67UTiSiXG66X1 7.6781e-24
C_3_317 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 BLB:n3s 1.0391e-23
C_3_318 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 1.9227e-19
C_3_319 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 BL:LM00Cobalt2XG492UTiSiXG484X1 2.6445e-24
C_3_320 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 BL:SiliconNXG479UTiSiXG484X1 3.3427e-25
C_3_321 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 BL:n2d 1.6109e-24
C_3_322 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 3.1720e-24
C_3_323 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 1.2477e-20
C_3_324 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 8.0247e-24
C_3_325 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 7.2606e-24
C_3_326 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 2.9786e-19
C_3_327 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.5880e-20
C_3_328 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 2.9447e-19
C_3_329 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 1.7959e-23
C_3_330 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 WL:n2g 6.0173e-25
C_3_331 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 WL:n3g 8.8260e-25
C_3_332 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.7134e-23
C_3_333 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.3597e-23
C_3_334 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.3603e-23
C_3_335 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.3579e-23
C_3_336 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:SDexcludeXG246UTiSiXG275X1 8.8917e-25
C_3_337 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:SDexcludeXG250UTiSiXG274X1 8.1981e-25
C_3_338 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:SiGeBXG261UTiSiXG275X1 1.8834e-26
C_3_339 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:SiGeBXG262UTiSiXG275X1 2.3775e-28
C_3_340 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:SiGeBXG265UTiSiXG275X1 2.2379e-28
C_3_341 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:SiGeBXG293UTiSiXG275X1 9.7263e-26
C_3_342 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:SiGeBXG297UTiSiXG275X1 2.5063e-28
C_3_343 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:SiliconNXG279UTiSiXG274X1 1.3589e-25
C_3_344 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:n1d 9.0631e-25
C_3_345 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:n2s 9.0631e-25
C_3_346 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:n4g 3.4335e-25
C_3_347 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:p1d 9.0756e-25
C_3_348 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ1:p2g 3.5880e-25
C_3_349 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.2929e-22
C_3_350 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 7.0507e-24
C_3_351 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 7.0204e-24
C_3_352 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 7.0207e-24
C_3_353 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:SDexcludeXG247UTiSiXG276X1 6.7961e-25
C_3_354 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:SDexcludeXG251UTiSiXG277X1 3.2888e-25
C_3_355 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:SiGeBXG266UTiSiXG276X1 3.0790e-26
C_3_356 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:SiGeBXG267UTiSiXG276X1 3.1891e-28
C_3_357 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:SiGeBXG270UTiSiXG276X1 2.5154e-28
C_3_358 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:SiliconNXG281UTiSiXG277X1 1.9443e-26
C_3_359 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:n1g 5.8430e-24
C_3_360 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:n3d 3.4718e-25
C_3_361 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:n4s 3.4718e-25
C_3_362 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:p1g 2.9644e-24
C_3_363 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 iQ2:p2s 7.0990e-25
C_3_364 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 WLL 4.0924e-20
C_3_365 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 WLR 4.0924e-20
C_3_366 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 1.5325e-22
C_3_367 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 8.0251e-23
C_3_368 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 BLB:SiliconNXG67UTiSiXG66X1 2.1687e-23
C_3_369 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 BLB:n3s 3.7403e-23
C_3_370 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 5.5139e-19
C_3_371 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 BL:LM00Cobalt2XG492UTiSiXG484X1 3.6304e-23
C_3_372 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 BL:SiliconNXG479UTiSiXG484X1 2.6334e-24
C_3_373 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 BL:n2d 1.3254e-23
C_3_374 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.8165e-21
C_3_375 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 2.6702e-19
C_3_376 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 2.6274e-23
C_3_377 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 4.1540e-24
C_3_378 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 4.6723e-20
C_3_379 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 2.7151e-19
C_3_380 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 4.0925e-20
C_3_381 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 3.9106e-24
C_3_382 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 WL:n2g 8.2301e-24
C_3_383 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 WL:n3g 5.1048e-24
C_3_384 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.1381e-20
C_3_385 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.1349e-20
C_3_386 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.1380e-20
C_3_387 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.1349e-20
C_3_388 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:SDexcludeXG246UTiSiXG275X1 7.8316e-24
C_3_389 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:SDexcludeXG250UTiSiXG274X1 4.4745e-23
C_3_390 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:SiGeBXG261UTiSiXG275X1 2.3089e-25
C_3_391 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:SiGeBXG262UTiSiXG275X1 3.8657e-27
C_3_392 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:SiGeBXG265UTiSiXG275X1 3.7935e-27
C_3_393 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:SiGeBXG293UTiSiXG275X1 1.0102e-25
C_3_394 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:SiGeBXG297UTiSiXG275X1 3.8367e-27
C_3_395 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:SiliconNXG279UTiSiXG274X1 8.0003e-23
C_3_396 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:n1d 6.2659e-23
C_3_397 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:n2s 6.2659e-23
C_3_398 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:n4g 3.0433e-24
C_3_399 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:p1d 8.0549e-24
C_3_400 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ1:p2g 3.0423e-24
C_3_401 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 3.8693e-20
C_3_402 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.5725e-23
C_3_403 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.5541e-23
C_3_404 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.5542e-23
C_3_405 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:SDexcludeXG247UTiSiXG276X1 5.4062e-24
C_3_406 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:SDexcludeXG251UTiSiXG277X1 2.7290e-24
C_3_407 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:SiGeBXG266UTiSiXG276X1 1.8614e-25
C_3_408 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:SiGeBXG267UTiSiXG276X1 1.5288e-27
C_3_409 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:SiGeBXG270UTiSiXG276X1 1.0181e-27
C_3_410 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:SiliconNXG281UTiSiXG277X1 1.2155e-25
C_3_411 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:n1g 2.1441e-22
C_3_412 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:n3d 2.8469e-24
C_3_413 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:n4s 2.8469e-24
C_3_414 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:p1g 2.3125e-23
C_3_415 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 iQ2:p2s 5.5903e-24
C_3_416 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 WLL 2.9795e-19
C_3_417 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 WLR 2.9795e-19
C_3_418 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 1.8940e-19
C_3_419 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 2.2094e-24
C_3_420 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 BLB:SiliconNXG67UTiSiXG66X1 2.9708e-25
C_3_421 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 BLB:n3s 1.5264e-24
C_3_422 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 1.9954e-22
C_3_423 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 BL:LM00Cobalt2XG492UTiSiXG484X1 5.1295e-23
C_3_424 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 BL:SiliconNXG479UTiSiXG484X1 8.2539e-24
C_3_425 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 BL:n2d 1.1146e-23
C_3_426 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 8.6563e-24
C_3_427 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 4.5755e-24
C_3_428 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 3.2059e-24
C_3_429 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 5.8868e-21
C_3_430 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 2.9796e-19
C_3_431 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.6586e-23
C_3_432 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 3.0096e-19
C_3_433 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 8.8938e-21
C_3_434 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 WL:n2g 9.7886e-25
C_3_435 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 WL:n3g 5.7398e-25
C_3_436 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 2.6069e-22
C_3_437 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 7.6397e-24
C_3_438 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 7.6044e-24
C_3_439 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 7.6037e-24
C_3_440 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:SDexcludeXG246UTiSiXG275X1 7.0574e-25
C_3_441 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:SDexcludeXG250UTiSiXG274X1 3.4122e-25
C_3_442 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:SiGeBXG261UTiSiXG275X1 3.6397e-26
C_3_443 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:SiGeBXG262UTiSiXG275X1 2.5251e-28
C_3_444 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:SiGeBXG265UTiSiXG275X1 2.2004e-28
C_3_445 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:SiGeBXG293UTiSiXG275X1 1.6819e-26
C_3_446 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:SiGeBXG297UTiSiXG275X1 6.6004e-28
C_3_447 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:SiliconNXG279UTiSiXG274X1 2.2765e-26
C_3_448 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:n1d 3.6212e-25
C_3_449 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:n2s 3.6212e-25
C_3_450 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:n4g 6.1963e-24
C_3_451 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:p1d 7.4170e-25
C_3_452 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ1:p2g 3.0044e-24
C_3_453 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.7679e-23
C_3_454 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.4382e-23
C_3_455 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.4355e-23
C_3_456 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.4386e-23
C_3_457 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:SDexcludeXG247UTiSiXG276X1 8.9648e-25
C_3_458 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:SDexcludeXG251UTiSiXG277X1 8.2269e-25
C_3_459 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:SiGeBXG266UTiSiXG276X1 2.7090e-26
C_3_460 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:SiGeBXG267UTiSiXG276X1 2.9759e-28
C_3_461 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:SiGeBXG270UTiSiXG276X1 2.2921e-28
C_3_462 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:SiliconNXG281UTiSiXG277X1 1.6959e-25
C_3_463 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:n1g 3.3582e-25
C_3_464 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:n3d 9.3160e-25
C_3_465 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:n4s 9.3160e-25
C_3_466 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:p1g 5.1697e-25
C_3_467 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 iQ2:p2s 9.2311e-25
C_3_468 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 WLL 4.8974e-20
C_3_469 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 WLR 4.8974e-20
C_3_470 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 6.1294e-19
C_3_471 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 7.7190e-23
C_3_472 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 BLB:SiliconNXG67UTiSiXG66X1 3.2394e-24
C_3_473 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 BLB:n3s 1.4297e-23
C_3_474 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 1.5453e-22
C_3_475 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 BL:LM00Cobalt2XG492UTiSiXG484X1 7.9738e-23
C_3_476 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 BL:SiliconNXG479UTiSiXG484X1 2.2004e-23
C_3_477 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 BL:n2d 3.8057e-23
C_3_478 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 2.6191e-23
C_3_479 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 2.9721e-24
C_3_480 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 3.6947e-21
C_3_481 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 2.6360e-19
C_3_482 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 4.8975e-20
C_3_483 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 3.0751e-24
C_3_484 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 5.8429e-20
C_3_485 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 2.7036e-19
C_3_486 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 WL:n2g 5.3241e-24
C_3_487 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 WL:n3g 1.1029e-23
C_3_488 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 5.2112e-20
C_3_489 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.6386e-23
C_3_490 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.6191e-23
C_3_491 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.6189e-23
C_3_492 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:SDexcludeXG246UTiSiXG275X1 5.5629e-24
C_3_493 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:SDexcludeXG250UTiSiXG274X1 2.8019e-24
C_3_494 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:SiGeBXG261UTiSiXG275X1 1.9876e-25
C_3_495 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:SiGeBXG262UTiSiXG275X1 9.6842e-28
C_3_496 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:SiGeBXG265UTiSiXG275X1 8.9294e-28
C_3_497 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:SiGeBXG293UTiSiXG275X1 9.2873e-27
C_3_498 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:SiGeBXG297UTiSiXG275X1 1.0340e-27
C_3_499 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:SiliconNXG279UTiSiXG274X1 1.3539e-25
C_3_500 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:n1d 2.9323e-24
C_3_501 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:n2s 2.9323e-24
C_3_502 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:n4g 3.1765e-22
C_3_503 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:p1d 5.7599e-24
C_3_504 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ1:p2g 2.4735e-23
C_3_505 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.6489e-20
C_3_506 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.6454e-20
C_3_507 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.6453e-20
C_3_508 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.6504e-20
C_3_509 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:SDexcludeXG247UTiSiXG276X1 8.0171e-24
C_3_510 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:SDexcludeXG251UTiSiXG277X1 6.7610e-23
C_3_511 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:SiGeBXG266UTiSiXG276X1 2.5054e-25
C_3_512 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:SiGeBXG267UTiSiXG276X1 6.0566e-27
C_3_513 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:SiGeBXG270UTiSiXG276X1 5.4251e-27
C_3_514 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:SiliconNXG281UTiSiXG277X1 1.5679e-22
C_3_515 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:n1g 3.1072e-24
C_3_516 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:n3d 1.2368e-22
C_3_517 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:n4s 1.2368e-22
C_3_518 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:p1g 3.1592e-24
C_3_519 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 iQ2:p2s 8.2568e-24
C_3_520 VSS:SiliconNXG31UTiSiXG30X1 WLL 1.7857e-23
C_3_521 VSS:SiliconNXG31UTiSiXG30X1 WLR 1.7857e-23
C_3_522 VSS:SiliconNXG31UTiSiXG30X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 1.2806e-21
C_3_523 VSS:SiliconNXG31UTiSiXG30X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 1.1768e-21
C_3_524 VSS:SiliconNXG31UTiSiXG30X1 BLB:SiliconNXG67UTiSiXG66X1 1.9910e-21
C_3_525 VSS:SiliconNXG31UTiSiXG30X1 BLB:n3s 7.9264e-21
C_3_526 VSS:SiliconNXG31UTiSiXG30X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 6.1994e-21
C_3_527 VSS:SiliconNXG31UTiSiXG30X1 BL:LM00Cobalt2XG492UTiSiXG484X1 1.5979e-22
C_3_528 VSS:SiliconNXG31UTiSiXG30X1 BL:SiliconNXG479UTiSiXG484X1 1.1349e-21
C_3_529 VSS:SiliconNXG31UTiSiXG30X1 BL:n2d 7.7548e-21
C_3_530 VSS:SiliconNXG31UTiSiXG30X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 1.0588e-20
C_3_531 VSS:SiliconNXG31UTiSiXG30X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 9.0345e-23
C_3_532 VSS:SiliconNXG31UTiSiXG30X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 5.8623e-21
C_3_533 VSS:SiliconNXG31UTiSiXG30X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 3.1664e-23
C_3_534 VSS:SiliconNXG31UTiSiXG30X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 1.8135e-23
C_3_535 VSS:SiliconNXG31UTiSiXG30X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 5.4072e-23
C_3_536 VSS:SiliconNXG31UTiSiXG30X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 1.8581e-23
C_3_537 VSS:SiliconNXG31UTiSiXG30X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 1.4007e-23
C_3_538 VSS:SiliconNXG31UTiSiXG30X1 WL:n2g 4.6453e-23
C_3_539 VSS:SiliconNXG31UTiSiXG30X1 WL:n3g 3.6724e-23
C_3_540 VSS:SiliconNXG31UTiSiXG30X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.3474e-20
C_3_541 VSS:SiliconNXG31UTiSiXG30X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 8.9234e-22
C_3_542 VSS:SiliconNXG31UTiSiXG30X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 9.7008e-22
C_3_543 VSS:SiliconNXG31UTiSiXG30X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 7.7130e-22
C_3_544 VSS:SiliconNXG31UTiSiXG30X1 iQ1:SDexcludeXG246UTiSiXG275X1 4.7830e-21
C_3_545 VSS:SiliconNXG31UTiSiXG30X1 iQ1:SDexcludeXG250UTiSiXG274X1 5.9486e-21
C_3_546 VSS:SiliconNXG31UTiSiXG30X1 iQ1:SiGeBXG261UTiSiXG275X1 1.2107e-22
C_3_547 VSS:SiliconNXG31UTiSiXG30X1 iQ1:SiGeBXG262UTiSiXG275X1 2.6007e-26
C_3_548 VSS:SiliconNXG31UTiSiXG30X1 iQ1:SiGeBXG265UTiSiXG275X1 1.5973e-26
C_3_549 VSS:SiliconNXG31UTiSiXG30X1 iQ1:SiGeBXG293UTiSiXG275X1 7.1401e-26
C_3_550 VSS:SiliconNXG31UTiSiXG30X1 iQ1:SiGeBXG297UTiSiXG275X1 1.5782e-26
C_3_551 VSS:SiliconNXG31UTiSiXG30X1 iQ1:SiliconNXG279UTiSiXG274X1 1.7253e-21
C_3_552 VSS:SiliconNXG31UTiSiXG30X1 iQ1:n1d 7.2762e-21
C_3_553 VSS:SiliconNXG31UTiSiXG30X1 iQ1:n2s 7.2762e-21
C_3_554 VSS:SiliconNXG31UTiSiXG30X1 iQ1:n4g 2.6119e-23
C_3_555 VSS:SiliconNXG31UTiSiXG30X1 iQ1:p1d 4.9041e-21
C_3_556 VSS:SiliconNXG31UTiSiXG30X1 iQ1:p2g 2.6317e-23
C_3_557 VSS:SiliconNXG31UTiSiXG30X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.4303e-18
C_3_558 VSS:SiliconNXG31UTiSiXG30X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.0167e-22
C_3_559 VSS:SiliconNXG31UTiSiXG30X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.2708e-22
C_3_560 VSS:SiliconNXG31UTiSiXG30X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.2732e-22
C_3_561 VSS:SiliconNXG31UTiSiXG30X1 iQ2:SDexcludeXG247UTiSiXG276X1 2.9293e-21
C_3_562 VSS:SiliconNXG31UTiSiXG30X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.5035e-21
C_3_563 VSS:SiliconNXG31UTiSiXG30X1 iQ2:SiGeBXG266UTiSiXG276X1 7.4645e-23
C_3_564 VSS:SiliconNXG31UTiSiXG30X1 iQ2:SiGeBXG267UTiSiXG276X1 3.4004e-26
C_3_565 VSS:SiliconNXG31UTiSiXG30X1 iQ2:SiGeBXG270UTiSiXG276X1 2.8339e-26
C_3_566 VSS:SiliconNXG31UTiSiXG30X1 iQ2:SiliconNXG281UTiSiXG277X1 6.0024e-23
C_3_567 VSS:SiliconNXG31UTiSiXG30X1 iQ2:n1g 3.3106e-21
C_3_568 VSS:SiliconNXG31UTiSiXG30X1 iQ2:n3d 1.5630e-21
C_3_569 VSS:SiliconNXG31UTiSiXG30X1 iQ2:n4s 1.5630e-21
C_3_570 VSS:SiliconNXG31UTiSiXG30X1 iQ2:p1g 4.5644e-22
C_3_571 VSS:SiliconNXG31UTiSiXG30X1 iQ2:p2s 3.0039e-21
C_3_572 VSS:SiliconNXG480UTiSiXG489X1 WLL 1.9755e-23
C_3_573 VSS:SiliconNXG480UTiSiXG489X1 WLR 1.9755e-23
C_3_574 VSS:SiliconNXG480UTiSiXG489X1 BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 6.3383e-21
C_3_575 VSS:SiliconNXG480UTiSiXG489X1 BLB:LM00Cobalt2XG63UTiSiXG66X1 1.6181e-22
C_3_576 VSS:SiliconNXG480UTiSiXG489X1 BLB:SiliconNXG67UTiSiXG66X1 1.1292e-21
C_3_577 VSS:SiliconNXG480UTiSiXG489X1 BLB:n3s 7.7187e-21
C_3_578 VSS:SiliconNXG480UTiSiXG489X1 BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 1.2547e-21
C_3_579 VSS:SiliconNXG480UTiSiXG489X1 BL:LM00Cobalt2XG492UTiSiXG484X1 1.1502e-21
C_3_580 VSS:SiliconNXG480UTiSiXG489X1 BL:SiliconNXG479UTiSiXG484X1 1.9977e-21
C_3_581 VSS:SiliconNXG480UTiSiXG489X1 BL:n2d 7.9518e-21
C_3_582 VSS:SiliconNXG480UTiSiXG489X1 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 5.6878e-21
C_3_583 VSS:SiliconNXG480UTiSiXG489X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 2.7450e-23
C_3_584 VSS:SiliconNXG480UTiSiXG489X1 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 1.0930e-20
C_3_585 VSS:SiliconNXG480UTiSiXG489X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 1.1067e-22
C_3_586 VSS:SiliconNXG480UTiSiXG489X1 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 2.1275e-23
C_3_587 VSS:SiliconNXG480UTiSiXG489X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 9.7463e-24
C_3_588 VSS:SiliconNXG480UTiSiXG489X1 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 1.9918e-23
C_3_589 VSS:SiliconNXG480UTiSiXG489X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 5.5691e-23
C_3_590 VSS:SiliconNXG480UTiSiXG489X1 WL:n2g 3.6726e-23
C_3_591 VSS:SiliconNXG480UTiSiXG489X1 WL:n3g 4.5739e-23
C_3_592 VSS:SiliconNXG480UTiSiXG489X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.4902e-18
C_3_593 VSS:SiliconNXG480UTiSiXG489X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 2.0452e-22
C_3_594 VSS:SiliconNXG480UTiSiXG489X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.2917e-22
C_3_595 VSS:SiliconNXG480UTiSiXG489X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.2877e-22
C_3_596 VSS:SiliconNXG480UTiSiXG489X1 iQ1:SDexcludeXG246UTiSiXG275X1 2.9348e-21
C_3_597 VSS:SiliconNXG480UTiSiXG489X1 iQ1:SDexcludeXG250UTiSiXG274X1 1.5075e-21
C_3_598 VSS:SiliconNXG480UTiSiXG489X1 iQ1:SiGeBXG261UTiSiXG275X1 7.5789e-23
C_3_599 VSS:SiliconNXG480UTiSiXG489X1 iQ1:SiGeBXG262UTiSiXG275X1 2.3011e-26
C_3_600 VSS:SiliconNXG480UTiSiXG489X1 iQ1:SiGeBXG265UTiSiXG275X1 2.2405e-26
C_3_601 VSS:SiliconNXG480UTiSiXG489X1 iQ1:SiGeBXG293UTiSiXG275X1 8.1501e-26
C_3_602 VSS:SiliconNXG480UTiSiXG489X1 iQ1:SiGeBXG297UTiSiXG275X1 2.2213e-26
C_3_603 VSS:SiliconNXG480UTiSiXG489X1 iQ1:SiliconNXG279UTiSiXG274X1 6.1279e-23
C_3_604 VSS:SiliconNXG480UTiSiXG489X1 iQ1:n1d 1.5679e-21
C_3_605 VSS:SiliconNXG480UTiSiXG489X1 iQ1:n2s 1.5679e-21
C_3_606 VSS:SiliconNXG480UTiSiXG489X1 iQ1:n4g 2.6566e-21
C_3_607 VSS:SiliconNXG480UTiSiXG489X1 iQ1:p1d 3.0106e-21
C_3_608 VSS:SiliconNXG480UTiSiXG489X1 iQ1:p2g 4.3458e-22
C_3_609 VSS:SiliconNXG480UTiSiXG489X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.3416e-20
C_3_610 VSS:SiliconNXG480UTiSiXG489X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 9.5221e-22
C_3_611 VSS:SiliconNXG480UTiSiXG489X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 8.3253e-22
C_3_612 VSS:SiliconNXG480UTiSiXG489X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.0002e-21
C_3_613 VSS:SiliconNXG480UTiSiXG489X1 iQ2:SDexcludeXG247UTiSiXG276X1 4.7726e-21
C_3_614 VSS:SiliconNXG480UTiSiXG489X1 iQ2:SDexcludeXG251UTiSiXG277X1 5.9152e-21
C_3_615 VSS:SiliconNXG480UTiSiXG489X1 iQ2:SiGeBXG266UTiSiXG276X1 1.1972e-22
C_3_616 VSS:SiliconNXG480UTiSiXG489X1 iQ2:SiGeBXG267UTiSiXG276X1 3.5759e-26
C_3_617 VSS:SiliconNXG480UTiSiXG489X1 iQ2:SiGeBXG270UTiSiXG276X1 2.1408e-26
C_3_618 VSS:SiliconNXG480UTiSiXG489X1 iQ2:SiliconNXG281UTiSiXG277X1 1.9222e-21
C_3_619 VSS:SiliconNXG480UTiSiXG489X1 iQ2:n1g 2.5853e-23
C_3_620 VSS:SiliconNXG480UTiSiXG489X1 iQ2:n3d 7.5020e-21
C_3_621 VSS:SiliconNXG480UTiSiXG489X1 iQ2:n4s 7.5020e-21
C_3_622 VSS:SiliconNXG480UTiSiXG489X1 iQ2:p1g 2.6023e-23
C_3_623 VSS:SiliconNXG480UTiSiXG489X1 iQ2:p2s 4.8923e-21
C_3_624 VSS:n1s WLL 1.8930e-23
C_3_625 VSS:n1s WLR 1.8930e-23
C_3_626 VSS:n1s BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 2.8477e-21
C_3_627 VSS:n1s BLB:LM00Cobalt2XG63UTiSiXG66X1 2.7091e-21
C_3_628 VSS:n1s BLB:SiliconNXG67UTiSiXG66X1 8.8740e-21
C_3_629 VSS:n1s BLB:n3s 4.5631e-20
C_3_630 VSS:n1s BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 7.1241e-21
C_3_631 VSS:n1s BL:LM00Cobalt2XG492UTiSiXG484X1 1.1899e-21
C_3_632 VSS:n1s BL:SiliconNXG479UTiSiXG484X1 8.5775e-21
C_3_633 VSS:n1s BL:n2d 5.9983e-20
C_3_634 VSS:n1s WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 7.6983e-20
C_3_635 VSS:n1s WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 1.7211e-22
C_3_636 VSS:n1s WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 3.5531e-20
C_3_637 VSS:n1s WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 9.5592e-23
C_3_638 VSS:n1s WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 2.0383e-23
C_3_639 VSS:n1s WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 8.2505e-23
C_3_640 VSS:n1s WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 2.0279e-23
C_3_641 VSS:n1s WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 3.4325e-23
C_3_642 VSS:n1s iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 9.1819e-20
C_3_643 VSS:n1s iQ1:LM00Cobalt2XG280USiGeBXG261X1 2.0386e-21
C_3_644 VSS:n1s iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.3139e-21
C_3_645 VSS:n1s iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.0431e-21
C_3_646 VSS:n1s iQ1:SDexcludeXG246UTiSiXG275X1 3.5533e-20
C_3_647 VSS:n1s iQ1:SDexcludeXG250UTiSiXG274X1 8.5519e-20
C_3_648 VSS:n1s iQ1:SiGeBXG261UTiSiXG275X1 9.9574e-22
C_3_649 VSS:n1s iQ1:SiGeBXG262UTiSiXG275X1 2.0576e-25
C_3_650 VSS:n1s iQ1:SiGeBXG265UTiSiXG275X1 1.3537e-25
C_3_651 VSS:n1s iQ1:SiGeBXG293UTiSiXG275X1 4.3677e-25
C_3_652 VSS:n1s iQ1:SiGeBXG297UTiSiXG275X1 1.3407e-25
C_3_653 VSS:n1s iQ1:SiliconNXG279UTiSiXG274X1 4.3779e-21
C_3_654 VSS:n1s iQ1:n1d 8.9355e-20
C_3_655 VSS:n1s iQ1:n2s 8.9355e-20
C_3_656 VSS:n1s iQ1:p1d 3.6529e-20
C_3_657 VSS:n1s iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 3.3771e-18
C_3_658 VSS:n1s iQ2:LM00Cobalt2XG117USiGeBXG266X1 7.0924e-22
C_3_659 VSS:n1s iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.1036e-22
C_3_660 VSS:n1s iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.1188e-22
C_3_661 VSS:n1s iQ2:SDexcludeXG247UTiSiXG276X1 1.9727e-20
C_3_662 VSS:n1s iQ2:SDexcludeXG251UTiSiXG277X1 1.0290e-20
C_3_663 VSS:n1s iQ2:SiGeBXG266UTiSiXG276X1 4.9909e-22
C_3_664 VSS:n1s iQ2:SiGeBXG267UTiSiXG276X1 1.3484e-25
C_3_665 VSS:n1s iQ2:SiGeBXG270UTiSiXG276X1 1.1093e-25
C_3_666 VSS:n1s iQ2:SiliconNXG281UTiSiXG277X1 4.0583e-22
C_3_667 VSS:n1s iQ2:n3d 1.0693e-20
C_3_668 VSS:n1s iQ2:n4s 1.0693e-20
C_3_669 VSS:n1s iQ2:p2s 2.0225e-20
C_3_670 VSS:n4d WLL 2.0901e-23
C_3_671 VSS:n4d WLR 2.0901e-23
C_3_672 VSS:n4d BLB:LM00Cobalt2XG63ULM40Cobalt5XG60X1 7.3346e-21
C_3_673 VSS:n4d BLB:LM00Cobalt2XG63UTiSiXG66X1 1.2053e-21
C_3_674 VSS:n4d BLB:SiliconNXG67UTiSiXG66X1 8.5440e-21
C_3_675 VSS:n4d BLB:n3s 5.9780e-20
C_3_676 VSS:n4d BL:LM00Cobalt2XG492ULM40Cobalt5XG39X1 2.8017e-21
C_3_677 VSS:n4d BL:LM00Cobalt2XG492UTiSiXG484X1 2.6602e-21
C_3_678 VSS:n4d BL:SiliconNXG479UTiSiXG484X1 8.9180e-21
C_3_679 VSS:n4d BL:n2d 4.5840e-20
C_3_680 VSS:n4d WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 3.4584e-20
C_3_681 VSS:n4d WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 8.5954e-23
C_3_682 VSS:n4d WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 7.8825e-20
C_3_683 VSS:n4d WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 2.0067e-22
C_3_684 VSS:n4d WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 2.3920e-23
C_3_685 VSS:n4d WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 2.3825e-23
C_3_686 VSS:n4d WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 2.1504e-23
C_3_687 VSS:n4d WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 8.9265e-23
C_3_688 VSS:n4d iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 3.4556e-18
C_3_689 VSS:n4d iQ1:LM00Cobalt2XG280USiGeBXG261X1 7.2134e-22
C_3_690 VSS:n4d iQ1:LM00Cobalt2XG280UTiSiXG274X1 2.1808e-22
C_3_691 VSS:n4d iQ1:LM00Cobalt2XG280UTiSiXG275X1 2.1557e-22
C_3_692 VSS:n4d iQ1:SDexcludeXG246UTiSiXG275X1 1.9782e-20
C_3_693 VSS:n4d iQ1:SDexcludeXG250UTiSiXG274X1 1.0327e-20
C_3_694 VSS:n4d iQ1:SiGeBXG261UTiSiXG275X1 5.0594e-22
C_3_695 VSS:n4d iQ1:SiGeBXG262UTiSiXG275X1 8.5525e-26
C_3_696 VSS:n4d iQ1:SiGeBXG265UTiSiXG275X1 8.5058e-26
C_3_697 VSS:n4d iQ1:SiGeBXG293UTiSiXG275X1 4.6154e-25
C_3_698 VSS:n4d iQ1:SiGeBXG297UTiSiXG275X1 8.3749e-26
C_3_699 VSS:n4d iQ1:SiliconNXG279UTiSiXG274X1 4.1322e-22
C_3_700 VSS:n4d iQ1:n1d 1.0735e-20
C_3_701 VSS:n4d iQ1:n2s 1.0735e-20
C_3_702 VSS:n4d iQ1:p1d 2.0288e-20
C_3_703 VSS:n4d iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 9.1065e-20
C_3_704 VSS:n4d iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.0898e-21
C_3_705 VSS:n4d iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.1051e-21
C_3_706 VSS:n4d iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.3241e-21
C_3_707 VSS:n4d iQ2:SDexcludeXG247UTiSiXG276X1 3.5497e-20
C_3_708 VSS:n4d iQ2:SDexcludeXG251UTiSiXG277X1 8.5356e-20
C_3_709 VSS:n4d iQ2:SiGeBXG266UTiSiXG276X1 9.8509e-22
C_3_710 VSS:n4d iQ2:SiGeBXG267UTiSiXG276X1 2.5664e-25
C_3_711 VSS:n4d iQ2:SiGeBXG270UTiSiXG276X1 1.7285e-25
C_3_712 VSS:n4d iQ2:SiliconNXG281UTiSiXG277X1 4.6028e-21
C_3_713 VSS:n4d iQ2:n3d 8.9520e-20
C_3_714 VSS:n4d iQ2:n4s 8.9520e-20
C_3_715 VSS:n4d iQ2:p2s 3.6481e-20
R_3_0 VSS VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 8.3942e+01
R_3_1 VSS VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 8.9453e+01
R_3_2 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 VSS:LM00Cobalt2XG16UTiSiXG30X1 2.3272e+02
R_3_3 VSS:LM00Cobalt2XG16ULM40Cobalt5XG20X1 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 3.0411e+02
R_3_4 VSS:LM00Cobalt2XG16UTiSiXG30X1 VSS:SiliconNXG31UTiSiXG30X1 2.0974e+02
R_3_5 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 VSS:LM00Cobalt2XG496UTiSiXG489X1 2.7108e+02
R_3_6 VSS:LM00Cobalt2XG496ULM40Cobalt5XG333X1 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 3.2416e+02
R_3_7 VSS:LM00Cobalt2XG496UTiSiXG489X1 VSS:SiliconNXG480UTiSiXG489X1 2.3525e+02
R_3_8 VSS:LM20Cobalt3XG22ULM30Cobalt4XG10X1 VSS:LM20Cobalt3XG22ULM40Cobalt5XG20X1 1.4423e+02
R_3_9 VSS:LM20Cobalt3XG474ULM30Cobalt4XG478X1 VSS:LM20Cobalt3XG474ULM40Cobalt5XG333X1 1.5635e+02
R_3_10 VSS:SiliconNXG31UTiSiXG30X1 VSS:n1s 4.0895e+01
R_3_11 VSS:SiliconNXG480UTiSiXG489X1 VSS:n4d 4.0945e+01

*|NET WL 9.2047e-05PF
C_4_0 WLL iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 2.4231e-22
C_4_1 WLL iQ1:LM00Cobalt2XG280USiGeBXG261X1 3.2307e-23
C_4_2 WLL iQ1:LM00Cobalt2XG280UTiSiXG274X1 3.2245e-23
C_4_3 WLL iQ1:LM00Cobalt2XG280UTiSiXG275X1 3.2238e-23
C_4_4 WLL iQ1:SDexcludeXG246UTiSiXG275X1 9.5943e-25
C_4_5 WLL iQ1:SDexcludeXG250UTiSiXG274X1 5.1839e-25
C_4_6 WLL iQ1:SiGeBXG261UTiSiXG275X1 6.9959e-26
C_4_7 WLL iQ1:SiGeBXG262UTiSiXG275X1 1.0341e-27
C_4_8 WLL iQ1:SiGeBXG265UTiSiXG275X1 8.8561e-28
C_4_9 WLL iQ1:SiGeBXG293UTiSiXG275X1 5.1770e-26
C_4_10 WLL iQ1:SiGeBXG297UTiSiXG275X1 1.0205e-27
C_4_11 WLL iQ1:SiliconNXG279UTiSiXG274X1 5.3032e-26
C_4_12 WLL iQ1:n1d 5.5588e-25
C_4_13 WLL iQ1:n2s 5.5588e-25
C_4_14 WLL iQ1:n4g 9.8735e-25
C_4_15 WLL iQ1:p1d 1.0276e-24
C_4_16 WLL iQ1:p2g 1.5397e-24
C_4_17 WLL iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.1320e-22
C_4_18 WLL iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.9073e-23
C_4_19 WLL iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.9017e-23
C_4_20 WLL iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.9022e-23
C_4_21 WLL iQ2:SDexcludeXG247UTiSiXG276X1 8.8835e-25
C_4_22 WLL iQ2:SDexcludeXG251UTiSiXG277X1 5.2381e-25
C_4_23 WLL iQ2:SiGeBXG266UTiSiXG276X1 5.7950e-26
C_4_24 WLL iQ2:SiGeBXG267UTiSiXG276X1 9.7163e-28
C_4_25 WLL iQ2:SiGeBXG270UTiSiXG276X1 9.2347e-28
C_4_26 WLL iQ2:SiliconNXG281UTiSiXG277X1 4.8902e-26
C_4_27 WLL iQ2:n1g 6.8883e-25
C_4_28 WLL iQ2:n3d 5.6201e-25
C_4_29 WLL iQ2:n4s 5.6201e-25
C_4_30 WLL iQ2:p1g 1.4227e-24
C_4_31 WLL iQ2:p2s 9.4445e-25
C_4_32 WLR iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 2.4231e-22
C_4_33 WLR iQ1:LM00Cobalt2XG280USiGeBXG261X1 3.2307e-23
C_4_34 WLR iQ1:LM00Cobalt2XG280UTiSiXG274X1 3.2245e-23
C_4_35 WLR iQ1:LM00Cobalt2XG280UTiSiXG275X1 3.2238e-23
C_4_36 WLR iQ1:SDexcludeXG246UTiSiXG275X1 9.5943e-25
C_4_37 WLR iQ1:SDexcludeXG250UTiSiXG274X1 5.1839e-25
C_4_38 WLR iQ1:SiGeBXG261UTiSiXG275X1 6.9959e-26
C_4_39 WLR iQ1:SiGeBXG262UTiSiXG275X1 1.0341e-27
C_4_40 WLR iQ1:SiGeBXG265UTiSiXG275X1 8.8561e-28
C_4_41 WLR iQ1:SiGeBXG293UTiSiXG275X1 5.1770e-26
C_4_42 WLR iQ1:SiGeBXG297UTiSiXG275X1 1.0205e-27
C_4_43 WLR iQ1:SiliconNXG279UTiSiXG274X1 5.3032e-26
C_4_44 WLR iQ1:n1d 5.5588e-25
C_4_45 WLR iQ1:n2s 5.5588e-25
C_4_46 WLR iQ1:n4g 9.8735e-25
C_4_47 WLR iQ1:p1d 1.0276e-24
C_4_48 WLR iQ1:p2g 1.5397e-24
C_4_49 WLR iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.1320e-22
C_4_50 WLR iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.9073e-23
C_4_51 WLR iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.9017e-23
C_4_52 WLR iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.9022e-23
C_4_53 WLR iQ2:SDexcludeXG247UTiSiXG276X1 8.8835e-25
C_4_54 WLR iQ2:SDexcludeXG251UTiSiXG277X1 5.2381e-25
C_4_55 WLR iQ2:SiGeBXG266UTiSiXG276X1 5.7950e-26
C_4_56 WLR iQ2:SiGeBXG267UTiSiXG276X1 9.7163e-28
C_4_57 WLR iQ2:SiGeBXG270UTiSiXG276X1 9.2347e-28
C_4_58 WLR iQ2:SiliconNXG281UTiSiXG277X1 4.8902e-26
C_4_59 WLR iQ2:n1g 6.8883e-25
C_4_60 WLR iQ2:n3d 5.6201e-25
C_4_61 WLR iQ2:n4s 5.6201e-25
C_4_62 WLR iQ2:p1g 1.4227e-24
C_4_63 WLR iQ2:p2s 9.4445e-25
C_4_64 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 3.9811e-18
C_4_65 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.3165e-18
C_4_66 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.3744e-18
C_4_67 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.2439e-18
C_4_68 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:SDexcludeXG246UTiSiXG275X1 1.0965e-19
C_4_69 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:SDexcludeXG250UTiSiXG274X1 7.2582e-19
C_4_70 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:SiGeBXG261UTiSiXG275X1 7.3434e-20
C_4_71 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:SiGeBXG262UTiSiXG275X1 4.4376e-22
C_4_72 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:SiGeBXG265UTiSiXG275X1 4.4374e-22
C_4_73 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:SiGeBXG293UTiSiXG275X1 4.4411e-22
C_4_74 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:SiGeBXG297UTiSiXG275X1 4.4374e-22
C_4_75 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:SiliconNXG279UTiSiXG274X1 7.6288e-19
C_4_76 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:n1d 1.2268e-18
C_4_77 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:n2s 1.2268e-18
C_4_78 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:n4g 1.1029e-20
C_4_79 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:p1d 1.8220e-19
C_4_80 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ1:p2g 1.4771e-20
C_4_81 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 6.4267e-19
C_4_82 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 5.3178e-22
C_4_83 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 7.5444e-23
C_4_84 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 7.6699e-23
C_4_85 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:SDexcludeXG247UTiSiXG276X1 1.7530e-20
C_4_86 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:SDexcludeXG251UTiSiXG277X1 8.6485e-21
C_4_87 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:SiGeBXG266UTiSiXG276X1 4.5650e-22
C_4_88 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:SiGeBXG267UTiSiXG276X1 1.8499e-25
C_4_89 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:SiGeBXG270UTiSiXG276X1 8.4149e-26
C_4_90 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:SiliconNXG281UTiSiXG277X1 3.4084e-22
C_4_91 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:n1g 1.1465e-19
C_4_92 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:n3d 8.9866e-21
C_4_93 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:n4s 8.9866e-21
C_4_94 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:p1g 3.0706e-20
C_4_95 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 iQ2:p2s 1.7986e-20
C_4_96 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.7061e-19
C_4_97 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.6568e-19
C_4_98 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.6601e-19
C_4_99 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.6567e-19
C_4_100 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:SDexcludeXG246UTiSiXG275X1 4.8817e-23
C_4_101 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:SDexcludeXG250UTiSiXG274X1 4.3290e-22
C_4_102 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:SiGeBXG261UTiSiXG275X1 4.3525e-24
C_4_103 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:SiGeBXG262UTiSiXG275X1 9.3495e-26
C_4_104 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:SiGeBXG265UTiSiXG275X1 9.1516e-26
C_4_105 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:SiGeBXG293UTiSiXG275X1 1.6498e-25
C_4_106 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:SiGeBXG297UTiSiXG275X1 9.1667e-26
C_4_107 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:SiliconNXG279UTiSiXG274X1 7.7448e-22
C_4_108 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:n1d 5.2909e-22
C_4_109 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:n2s 5.2909e-22
C_4_110 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:n4g 2.0340e-23
C_4_111 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:p1d 5.2986e-23
C_4_112 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ1:p2g 4.0595e-23
C_4_113 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 3.5586e-20
C_4_114 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 3.8752e-24
C_4_115 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 3.1336e-24
C_4_116 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 3.1356e-24
C_4_117 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:SDexcludeXG247UTiSiXG276X1 2.8722e-23
C_4_118 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.4346e-23
C_4_119 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:SiGeBXG266UTiSiXG276X1 7.4449e-25
C_4_120 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:SiGeBXG267UTiSiXG276X1 2.7800e-27
C_4_121 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:SiGeBXG270UTiSiXG276X1 1.4389e-27
C_4_122 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:SiliconNXG281UTiSiXG277X1 5.4996e-25
C_4_123 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:n1g 2.7648e-22
C_4_124 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:n3d 1.4889e-23
C_4_125 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:n4s 1.4889e-23
C_4_126 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:p1g 2.2089e-23
C_4_127 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 iQ2:p2s 2.9464e-23
C_4_128 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 6.7477e-19
C_4_129 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 5.5237e-22
C_4_130 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 7.9100e-23
C_4_131 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 7.6968e-23
C_4_132 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:SDexcludeXG246UTiSiXG275X1 1.8078e-20
C_4_133 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:SDexcludeXG250UTiSiXG274X1 8.9023e-21
C_4_134 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:SiGeBXG261UTiSiXG275X1 4.7553e-22
C_4_135 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:SiGeBXG262UTiSiXG275X1 7.8917e-26
C_4_136 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:SiGeBXG265UTiSiXG275X1 6.8274e-26
C_4_137 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:SiGeBXG293UTiSiXG275X1 4.5214e-25
C_4_138 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:SiGeBXG297UTiSiXG275X1 6.7744e-26
C_4_139 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:SiliconNXG279UTiSiXG274X1 3.5521e-22
C_4_140 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:n1d 9.2531e-21
C_4_141 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:n2s 9.2531e-21
C_4_142 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:n4g 1.1719e-19
C_4_143 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:p1d 1.8554e-20
C_4_144 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ1:p2g 3.2406e-20
C_4_145 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 4.1927e-18
C_4_146 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.3099e-18
C_4_147 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.2306e-18
C_4_148 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.3545e-18
C_4_149 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:SDexcludeXG247UTiSiXG276X1 1.1822e-19
C_4_150 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:SDexcludeXG251UTiSiXG277X1 7.3302e-19
C_4_151 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:SiGeBXG266UTiSiXG276X1 8.0629e-20
C_4_152 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:SiGeBXG267UTiSiXG276X1 6.5994e-22
C_4_153 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:SiGeBXG270UTiSiXG276X1 6.5983e-22
C_4_154 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:SiliconNXG281UTiSiXG277X1 8.0649e-19
C_4_155 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:n1g 1.1344e-20
C_4_156 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:n3d 1.2904e-18
C_4_157 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:n4s 1.2904e-18
C_4_158 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:p1g 1.5239e-20
C_4_159 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 iQ2:p2s 1.9753e-19
C_4_160 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 3.1667e-20
C_4_161 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 4.0607e-24
C_4_162 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 3.2481e-24
C_4_163 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 3.2452e-24
C_4_164 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:SDexcludeXG246UTiSiXG275X1 3.1195e-23
C_4_165 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:SDexcludeXG250UTiSiXG274X1 1.5590e-23
C_4_166 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:SiGeBXG261UTiSiXG275X1 8.1816e-25
C_4_167 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:SiGeBXG262UTiSiXG275X1 1.7090e-27
C_4_168 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:SiGeBXG265UTiSiXG275X1 1.3618e-27
C_4_169 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:SiGeBXG293UTiSiXG275X1 3.6113e-27
C_4_170 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:SiGeBXG297UTiSiXG275X1 1.3638e-27
C_4_171 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:SiliconNXG279UTiSiXG274X1 6.2602e-25
C_4_172 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:n1d 1.6207e-23
C_4_173 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:n2s 1.6207e-23
C_4_174 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:n4g 3.1849e-22
C_4_175 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:p1d 3.2010e-23
C_4_176 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ1:p2g 2.3766e-23
C_4_177 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.5564e-19
C_4_178 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.5047e-19
C_4_179 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.5047e-19
C_4_180 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.5090e-19
C_4_181 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:SDexcludeXG247UTiSiXG276X1 5.2285e-23
C_4_182 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:SDexcludeXG251UTiSiXG277X1 5.4060e-22
C_4_183 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:SiGeBXG266UTiSiXG276X1 3.9630e-24
C_4_184 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:SiGeBXG267UTiSiXG276X1 9.9843e-26
C_4_185 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:SiGeBXG270UTiSiXG276X1 9.6610e-26
C_4_186 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:SiliconNXG281UTiSiXG277X1 1.2102e-21
C_4_187 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:n1g 2.2131e-23
C_4_188 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:n3d 8.8083e-22
C_4_189 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:n4s 8.8083e-22
C_4_190 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:p1g 4.4522e-23
C_4_191 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 iQ2:p2s 5.6055e-23
C_4_192 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 4.5657e-22
C_4_193 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 6.4822e-23
C_4_194 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 6.4687e-23
C_4_195 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 6.4672e-23
C_4_196 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:SDexcludeXG246UTiSiXG275X1 2.0291e-24
C_4_197 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:SDexcludeXG250UTiSiXG274X1 1.3536e-24
C_4_198 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:SiGeBXG261UTiSiXG275X1 1.5381e-25
C_4_199 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:SiGeBXG262UTiSiXG275X1 1.9284e-27
C_4_200 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:SiGeBXG265UTiSiXG275X1 1.7510e-27
C_4_201 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:SiGeBXG293UTiSiXG275X1 2.5348e-25
C_4_202 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:SiGeBXG297UTiSiXG275X1 2.2587e-27
C_4_203 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:SiliconNXG279UTiSiXG274X1 1.2771e-25
C_4_204 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:n1d 1.4481e-24
C_4_205 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:n2s 1.4481e-24
C_4_206 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:n4g 1.4854e-24
C_4_207 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:p1d 2.1794e-24
C_4_208 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ1:p2g 2.8336e-24
C_4_209 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.1932e-22
C_4_210 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.9295e-23
C_4_211 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.9218e-23
C_4_212 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.9224e-23
C_4_213 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:SDexcludeXG247UTiSiXG276X1 1.5525e-24
C_4_214 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:SDexcludeXG251UTiSiXG277X1 8.3356e-25
C_4_215 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:SiGeBXG266UTiSiXG276X1 7.9240e-26
C_4_216 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:SiGeBXG267UTiSiXG276X1 1.0879e-27
C_4_217 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:SiGeBXG270UTiSiXG276X1 1.0338e-27
C_4_218 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:SiliconNXG281UTiSiXG277X1 6.5299e-26
C_4_219 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:n1g 1.2935e-24
C_4_220 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:n3d 8.8505e-25
C_4_221 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:n4s 8.8505e-25
C_4_222 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:p1g 1.8700e-24
C_4_223 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 iQ2:p2s 1.6297e-24
C_4_224 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 4.6422e-20
C_4_225 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 4.4906e-20
C_4_226 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 4.4949e-20
C_4_227 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 4.4905e-20
C_4_228 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:SDexcludeXG246UTiSiXG275X1 1.0937e-23
C_4_229 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:SDexcludeXG250UTiSiXG274X1 6.0167e-23
C_4_230 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:SiGeBXG261UTiSiXG275X1 9.9259e-25
C_4_231 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:SiGeBXG262UTiSiXG275X1 2.0654e-26
C_4_232 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:SiGeBXG265UTiSiXG275X1 2.0293e-26
C_4_233 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:SiGeBXG293UTiSiXG275X1 2.8475e-25
C_4_234 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:SiGeBXG297UTiSiXG275X1 2.0716e-26
C_4_235 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:SiliconNXG279UTiSiXG274X1 1.0785e-22
C_4_236 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:n1d 8.0872e-23
C_4_237 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:n2s 8.0872e-23
C_4_238 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:n4g 4.8034e-24
C_4_239 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:p1d 1.1889e-23
C_4_240 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ1:p2g 1.0981e-23
C_4_241 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.5641e-20
C_4_242 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.9600e-24
C_4_243 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.7802e-24
C_4_244 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.7826e-24
C_4_245 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:SDexcludeXG247UTiSiXG276X1 6.5108e-24
C_4_246 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:SDexcludeXG251UTiSiXG277X1 3.2008e-24
C_4_247 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:SiGeBXG266UTiSiXG276X1 1.8126e-25
C_4_248 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:SiGeBXG267UTiSiXG276X1 8.7015e-28
C_4_249 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:SiGeBXG270UTiSiXG276X1 7.4664e-28
C_4_250 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:SiliconNXG281UTiSiXG277X1 1.2919e-25
C_4_251 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:n1g 1.2125e-22
C_4_252 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:n3d 3.3238e-24
C_4_253 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:n4s 3.3238e-24
C_4_254 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:p1g 5.2813e-24
C_4_255 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 iQ2:p2s 6.6905e-24
C_4_256 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 2.4592e-22
C_4_257 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 3.2409e-23
C_4_258 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 3.2340e-23
C_4_259 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 3.2333e-23
C_4_260 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:SDexcludeXG246UTiSiXG275X1 1.2295e-24
C_4_261 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:SDexcludeXG250UTiSiXG274X1 6.4992e-25
C_4_262 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:SiGeBXG261UTiSiXG275X1 7.7788e-26
C_4_263 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:SiGeBXG262UTiSiXG275X1 1.1003e-27
C_4_264 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:SiGeBXG265UTiSiXG275X1 9.2484e-28
C_4_265 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:SiGeBXG293UTiSiXG275X1 5.2927e-26
C_4_266 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:SiGeBXG297UTiSiXG275X1 1.0656e-27
C_4_267 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:SiliconNXG279UTiSiXG274X1 5.8283e-26
C_4_268 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:n1d 6.9258e-25
C_4_269 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:n2s 6.9258e-25
C_4_270 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:n4g 1.2288e-24
C_4_271 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:p1d 1.3054e-24
C_4_272 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ1:p2g 1.7173e-24
C_4_273 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 3.0923e-22
C_4_274 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 4.4540e-23
C_4_275 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 4.4454e-23
C_4_276 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 4.4463e-23
C_4_277 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:SDexcludeXG247UTiSiXG276X1 1.3159e-24
C_4_278 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:SDexcludeXG251UTiSiXG277X1 8.4880e-25
C_4_279 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:SiGeBXG266UTiSiXG276X1 8.9106e-26
C_4_280 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:SiGeBXG267UTiSiXG276X1 1.4094e-27
C_4_281 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:SiGeBXG270UTiSiXG276X1 1.3448e-27
C_4_282 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:SiliconNXG281UTiSiXG277X1 8.0915e-26
C_4_283 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:n1g 8.9802e-25
C_4_284 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:n3d 9.0910e-25
C_4_285 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:n4s 9.0910e-25
C_4_286 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:p1g 1.9640e-24
C_4_287 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 iQ2:p2s 1.4023e-24
C_4_288 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.8861e-20
C_4_289 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:LM00Cobalt2XG280USiGeBXG261X1 2.1985e-24
C_4_290 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.9421e-24
C_4_291 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.9415e-24
C_4_292 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:SDexcludeXG246UTiSiXG275X1 9.3760e-24
C_4_293 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:SDexcludeXG250UTiSiXG274X1 4.6243e-24
C_4_294 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:SiGeBXG261UTiSiXG275X1 2.5848e-25
C_4_295 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:SiGeBXG262UTiSiXG275X1 8.9358e-28
C_4_296 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:SiGeBXG265UTiSiXG275X1 7.5830e-28
C_4_297 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:SiGeBXG293UTiSiXG275X1 3.4323e-27
C_4_298 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:SiGeBXG297UTiSiXG275X1 7.6447e-28
C_4_299 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:SiliconNXG279UTiSiXG274X1 1.8713e-25
C_4_300 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:n1d 4.8088e-24
C_4_301 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:n2s 4.8088e-24
C_4_302 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:n4g 1.1117e-22
C_4_303 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:p1d 9.6330e-24
C_4_304 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ1:p2g 7.2396e-24
C_4_305 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 3.9410e-20
C_4_306 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 3.7392e-20
C_4_307 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 3.7390e-20
C_4_308 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 3.7434e-20
C_4_309 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:SDexcludeXG247UTiSiXG276X1 1.5510e-23
C_4_310 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:SDexcludeXG251UTiSiXG277X1 6.3553e-23
C_4_311 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:SiGeBXG266UTiSiXG276X1 1.1715e-24
C_4_312 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:SiGeBXG267UTiSiXG276X1 2.4964e-26
C_4_313 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:SiGeBXG270UTiSiXG276X1 2.4358e-26
C_4_314 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:SiliconNXG281UTiSiXG277X1 1.3049e-22
C_4_315 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:n1g 6.8602e-24
C_4_316 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:n3d 1.0675e-22
C_4_317 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:n4s 1.0675e-22
C_4_318 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:p1g 1.5595e-23
C_4_319 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 iQ2:p2s 1.6633e-23
C_4_320 WL:n2g iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 3.1717e-19
C_4_321 WL:n2g iQ1:LM00Cobalt2XG280USiGeBXG261X1 9.6577e-20
C_4_322 WL:n2g iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.8578e-19
C_4_323 WL:n2g iQ1:LM00Cobalt2XG280UTiSiXG275X1 9.6596e-20
C_4_324 WL:n2g iQ1:SDexcludeXG246UTiSiXG275X1 1.8431e-23
C_4_325 WL:n2g iQ1:SDexcludeXG250UTiSiXG274X1 8.9207e-20
C_4_326 WL:n2g iQ1:SiGeBXG261UTiSiXG275X1 1.8431e-23
C_4_327 WL:n2g iQ1:SiGeBXG262UTiSiXG275X1 1.8431e-23
C_4_328 WL:n2g iQ1:SiGeBXG265UTiSiXG275X1 1.8431e-23
C_4_329 WL:n2g iQ1:SiGeBXG293UTiSiXG275X1 1.8431e-23
C_4_330 WL:n2g iQ1:SiGeBXG297UTiSiXG275X1 1.8431e-23
C_4_331 WL:n2g iQ1:SiliconNXG279UTiSiXG274X1 8.9207e-20
C_4_332 WL:n2g iQ1:n4g 4.4314e-21
C_4_333 WL:n2g iQ1:p2g 5.4949e-21
C_4_334 WL:n2g iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.4029e-19
C_4_335 WL:n2g iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.6381e-23
C_4_336 WL:n2g iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.6406e-23
C_4_337 WL:n2g iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.6920e-23
C_4_338 WL:n2g iQ2:SDexcludeXG247UTiSiXG276X1 2.5016e-26
C_4_339 WL:n2g iQ2:SDexcludeXG251UTiSiXG277X1 5.3970e-25
C_4_340 WL:n2g iQ2:SiGeBXG266UTiSiXG276X1 2.5016e-26
C_4_341 WL:n2g iQ2:SiGeBXG267UTiSiXG276X1 2.5016e-26
C_4_342 WL:n2g iQ2:SiGeBXG270UTiSiXG276X1 2.5016e-26
C_4_343 WL:n2g iQ2:SiliconNXG281UTiSiXG277X1 5.3970e-25
C_4_344 WL:n2g iQ2:n1g 3.2955e-20
C_4_345 WL:n2g iQ2:p1g 1.0010e-20
C_4_346 WL:n3g iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 1.3740e-19
C_4_347 WL:n3g iQ1:LM00Cobalt2XG280USiGeBXG261X1 1.6833e-23
C_4_348 WL:n3g iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.7690e-23
C_4_349 WL:n3g iQ1:LM00Cobalt2XG280UTiSiXG275X1 1.6853e-23
C_4_350 WL:n3g iQ1:SDexcludeXG246UTiSiXG275X1 2.0023e-26
C_4_351 WL:n3g iQ1:SDexcludeXG250UTiSiXG274X1 8.5680e-25
C_4_352 WL:n3g iQ1:SiGeBXG261UTiSiXG275X1 2.0023e-26
C_4_353 WL:n3g iQ1:SiGeBXG262UTiSiXG275X1 2.0023e-26
C_4_354 WL:n3g iQ1:SiGeBXG265UTiSiXG275X1 2.0023e-26
C_4_355 WL:n3g iQ1:SiGeBXG293UTiSiXG275X1 2.0023e-26
C_4_356 WL:n3g iQ1:SiGeBXG297UTiSiXG275X1 2.0023e-26
C_4_357 WL:n3g iQ1:SiliconNXG279UTiSiXG274X1 8.5680e-25
C_4_358 WL:n3g iQ1:n4g 3.2503e-20
C_4_359 WL:n3g iQ1:p2g 9.7397e-21
C_4_360 WL:n3g iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.9136e-19
C_4_361 WL:n3g iQ2:LM00Cobalt2XG117USiGeBXG266X1 9.2740e-20
C_4_362 WL:n3g iQ2:LM00Cobalt2XG117UTiSiXG276X1 9.2759e-20
C_4_363 WL:n3g iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.8042e-19
C_4_364 WL:n3g iQ2:SDexcludeXG247UTiSiXG276X1 1.9291e-23
C_4_365 WL:n3g iQ2:SDexcludeXG251UTiSiXG277X1 8.7683e-20
C_4_366 WL:n3g iQ2:SiGeBXG266UTiSiXG276X1 1.9291e-23
C_4_367 WL:n3g iQ2:SiGeBXG267UTiSiXG276X1 1.9291e-23
C_4_368 WL:n3g iQ2:SiGeBXG270UTiSiXG276X1 1.9291e-23
C_4_369 WL:n3g iQ2:SiliconNXG281UTiSiXG277X1 8.7683e-20
C_4_370 WL:n3g iQ2:n1g 4.4008e-21
C_4_371 WL:n3g iQ2:p1g 5.4275e-21
R_4_0 WLL WLR 5.4532e+00
R_4_1 WLL WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 3.4429e+01
R_4_2 WLL WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 2.0292e+03
R_4_3 WLR WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 1.9661e+03
R_4_4 WLR WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 3.5818e+01
R_4_5 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 1.3273e+02
R_4_6 WL:LM00Cobalt2XG313ULM10Tungsten1XG328X1 WL:n2g 4.6423e+01
R_4_7 WL:LM00Cobalt2XG313ULM40Cobalt5XG256X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 1.5067e+02
R_4_8 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 1.3268e+02
R_4_9 WL:LM00Cobalt2XG85ULM10Tungsten1XG145X1 WL:n3g 4.6136e+01
R_4_10 WL:LM00Cobalt2XG85ULM40Cobalt5XG77X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 1.4333e+02
R_4_11 WL:LM20Cobalt3XG289ULM30Cobalt4XG102X1 WL:LM20Cobalt3XG289ULM40Cobalt5XG256X1 5.8126e+01
R_4_12 WL:LM20Cobalt3XG82ULM30Cobalt4XG102X1 WL:LM20Cobalt3XG82ULM40Cobalt5XG77X1 6.0013e+01

*|NET iQ1 8.3366e-05PF
C_5_0 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 5.6308e-18
C_5_1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.9979e-18
C_5_2 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.1421e-18
C_5_3 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.2430e-18
C_5_4 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:SDexcludeXG247UTiSiXG276X1 1.0025e-18
C_5_5 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:SDexcludeXG251UTiSiXG277X1 7.4556e-19
C_5_6 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:SiGeBXG266UTiSiXG276X1 8.8532e-19
C_5_7 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:SiGeBXG267UTiSiXG276X1 1.4779e-20
C_5_8 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:SiGeBXG270UTiSiXG276X1 1.4779e-20
C_5_9 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:SiliconNXG281UTiSiXG277X1 7.8571e-19
C_5_10 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:n1g 1.5151e-19
C_5_11 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:n3d 1.2999e-18
C_5_12 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:n4s 1.2999e-18
C_5_13 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:p1g 1.9980e-19
C_5_14 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ2:p2s 1.8582e-18
C_5_15 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 3.0113e-18
C_5_16 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 5.8717e-20
C_5_17 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.1613e-20
C_5_18 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.1519e-20
C_5_19 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:SDexcludeXG247UTiSiXG276X1 5.9759e-21
C_5_20 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.6284e-22
C_5_21 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:SiGeBXG266UTiSiXG276X1 3.7293e-20
C_5_22 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:SiGeBXG267UTiSiXG276X1 9.4003e-23
C_5_23 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:SiGeBXG270UTiSiXG276X1 9.3962e-23
C_5_24 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:SiliconNXG281UTiSiXG277X1 7.1240e-24
C_5_25 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:n1g 9.4285e-20
C_5_26 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:n3d 1.6989e-22
C_5_27 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:n4s 1.6989e-22
C_5_28 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:p1g 8.1250e-20
C_5_29 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ2:p2s 4.3081e-20
C_5_30 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.2695e-18
C_5_31 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.1537e-20
C_5_32 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.8800e-20
C_5_33 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.8761e-20
C_5_34 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:SDexcludeXG247UTiSiXG276X1 2.4442e-22
C_5_35 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.5154e-23
C_5_36 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:SiGeBXG266UTiSiXG276X1 2.8138e-21
C_5_37 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:SiGeBXG267UTiSiXG276X1 3.8397e-23
C_5_38 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:SiGeBXG270UTiSiXG276X1 3.8358e-23
C_5_39 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:SiliconNXG281UTiSiXG277X1 5.8663e-25
C_5_40 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:n1g 1.8337e-19
C_5_41 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:n3d 1.5710e-23
C_5_42 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:n4s 1.5710e-23
C_5_43 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:p1g 8.1280e-20
C_5_44 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ2:p2s 2.9815e-21
C_5_45 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 2.1608e-18
C_5_46 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 2.1621e-20
C_5_47 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.8835e-20
C_5_48 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.8796e-20
C_5_49 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:SDexcludeXG247UTiSiXG276X1 2.4554e-22
C_5_50 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.4480e-23
C_5_51 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:SiGeBXG266UTiSiXG276X1 2.8633e-21
C_5_52 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:SiGeBXG267UTiSiXG276X1 3.8742e-23
C_5_53 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:SiGeBXG270UTiSiXG276X1 3.8702e-23
C_5_54 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:SiliconNXG281UTiSiXG277X1 5.6264e-25
C_5_55 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:n1g 9.4291e-20
C_5_56 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:n3d 1.5013e-23
C_5_57 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:n4s 1.5013e-23
C_5_58 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:p1g 8.8870e-20
C_5_59 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ2:p2s 3.0315e-21
C_5_60 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.0026e-18
C_5_61 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 5.9672e-21
C_5_62 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.4065e-22
C_5_63 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.3877e-22
C_5_64 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:SDexcludeXG247UTiSiXG276X1 3.1405e-20
C_5_65 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:SDexcludeXG251UTiSiXG277X1 5.6249e-21
C_5_66 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:SiGeBXG266UTiSiXG276X1 5.7320e-21
C_5_67 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:SiGeBXG267UTiSiXG276X1 2.7308e-24
C_5_68 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:SiGeBXG270UTiSiXG276X1 2.7288e-24
C_5_69 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:SiliconNXG281UTiSiXG277X1 2.3621e-22
C_5_70 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:n1g 5.8877e-24
C_5_71 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:n3d 5.8594e-21
C_5_72 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:n4s 5.8594e-21
C_5_73 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:p1g 7.6201e-21
C_5_74 iQ1:SDexcludeXG246UTiSiXG275X1 iQ2:p2s 3.7131e-20
C_5_75 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 7.5285e-19
C_5_76 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.6119e-22
C_5_77 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.3803e-23
C_5_78 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.4214e-23
C_5_79 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:SDexcludeXG247UTiSiXG276X1 5.6345e-21
C_5_80 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:SDexcludeXG251UTiSiXG277X1 2.8337e-21
C_5_81 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:SiGeBXG266UTiSiXG276X1 1.4743e-22
C_5_82 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:SiGeBXG267UTiSiXG276X1 2.8972e-26
C_5_83 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:SiGeBXG270UTiSiXG276X1 2.1620e-26
C_5_84 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:SiliconNXG281UTiSiXG277X1 1.1145e-22
C_5_85 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:n1g 8.9087e-20
C_5_86 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:n3d 2.9443e-21
C_5_87 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:n4s 2.9443e-21
C_5_88 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:p1g 3.0480e-23
C_5_89 iQ1:SDexcludeXG250UTiSiXG274X1 iQ2:p2s 5.7819e-21
C_5_90 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 8.7616e-19
C_5_91 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 3.7265e-20
C_5_92 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 2.8479e-21
C_5_93 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.7920e-21
C_5_94 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:SDexcludeXG247UTiSiXG276X1 5.7352e-21
C_5_95 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.4839e-22
C_5_96 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:SiGeBXG266UTiSiXG276X1 3.4529e-20
C_5_97 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:SiGeBXG267UTiSiXG276X1 5.5951e-23
C_5_98 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:SiGeBXG270UTiSiXG276X1 5.5947e-23
C_5_99 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:SiliconNXG281UTiSiXG277X1 6.5618e-24
C_5_100 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:n1g 5.8877e-24
C_5_101 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:n3d 1.5491e-22
C_5_102 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:n4s 1.5491e-22
C_5_103 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:p1g 7.6201e-21
C_5_104 iQ1:SiGeBXG261UTiSiXG275X1 iQ2:p2s 4.0152e-20
C_5_105 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.2857e-20
C_5_106 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 8.3855e-23
C_5_107 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 3.4962e-23
C_5_108 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 3.4618e-23
C_5_109 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:SDexcludeXG247UTiSiXG276X1 2.4618e-24
C_5_110 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.9739e-26
C_5_111 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:SiGeBXG266UTiSiXG276X1 4.9580e-23
C_5_112 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:SiGeBXG267UTiSiXG276X1 3.4516e-25
C_5_113 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:SiGeBXG270UTiSiXG276X1 3.4382e-25
C_5_114 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:SiliconNXG281UTiSiXG277X1 1.9337e-27
C_5_115 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:n1g 5.8877e-24
C_5_116 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:n3d 2.1584e-26
C_5_117 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:n4s 2.1584e-26
C_5_118 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:p1g 7.6201e-21
C_5_119 iQ1:SiGeBXG262UTiSiXG275X1 iQ2:p2s 5.1354e-23
C_5_120 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.2856e-20
C_5_121 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 8.3960e-23
C_5_122 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 3.5019e-23
C_5_123 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 3.4675e-23
C_5_124 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:SDexcludeXG247UTiSiXG276X1 2.4639e-24
C_5_125 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.6966e-26
C_5_126 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:SiGeBXG266UTiSiXG276X1 4.9629e-23
C_5_127 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:SiGeBXG267UTiSiXG276X1 3.4539e-25
C_5_128 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:SiGeBXG270UTiSiXG276X1 3.4404e-25
C_5_129 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:SiliconNXG281UTiSiXG277X1 2.2038e-28
C_5_130 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:n1g 5.8877e-24
C_5_131 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:n3d 1.7121e-26
C_5_132 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:n4s 1.7121e-26
C_5_133 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:p1g 7.6201e-21
C_5_134 iQ1:SiGeBXG265UTiSiXG275X1 iQ2:p2s 5.1405e-23
C_5_135 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.2837e-20
C_5_136 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 8.3849e-23
C_5_137 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 3.4965e-23
C_5_138 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 3.4622e-23
C_5_139 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:SDexcludeXG247UTiSiXG276X1 2.6044e-24
C_5_140 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.1706e-25
C_5_141 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:SiGeBXG266UTiSiXG276X1 4.9571e-23
C_5_142 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:SiGeBXG267UTiSiXG276X1 3.4495e-25
C_5_143 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:SiGeBXG270UTiSiXG276X1 3.4361e-25
C_5_144 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:SiliconNXG281UTiSiXG277X1 4.7664e-27
C_5_145 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:n1g 5.8877e-24
C_5_146 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:n3d 1.2172e-25
C_5_147 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:n4s 1.2172e-25
C_5_148 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:p1g 7.6201e-21
C_5_149 iQ1:SiGeBXG293UTiSiXG275X1 iQ2:p2s 5.1488e-23
C_5_150 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.2836e-20
C_5_151 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 8.3838e-23
C_5_152 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 3.4958e-23
C_5_153 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 3.4614e-23
C_5_154 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:SDexcludeXG247UTiSiXG276X1 2.4611e-24
C_5_155 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.6644e-26
C_5_156 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:SiGeBXG266UTiSiXG276X1 4.9567e-23
C_5_157 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:SiGeBXG267UTiSiXG276X1 3.4494e-25
C_5_158 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:SiGeBXG270UTiSiXG276X1 3.4360e-25
C_5_159 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:SiliconNXG281UTiSiXG277X1 2.0830e-28
C_5_160 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:n1g 5.8877e-24
C_5_161 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:n3d 1.6787e-26
C_5_162 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:n4s 1.6787e-26
C_5_163 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:p1g 7.6201e-21
C_5_164 iQ1:SiGeBXG297UTiSiXG275X1 iQ2:p2s 5.1341e-23
C_5_165 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 7.6770e-19
C_5_166 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:LM00Cobalt2XG117USiGeBXG266X1 7.2576e-24
C_5_167 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 6.1801e-25
C_5_168 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 6.3893e-25
C_5_169 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:SDexcludeXG247UTiSiXG276X1 2.4017e-22
C_5_170 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:SDexcludeXG251UTiSiXG277X1 1.1287e-22
C_5_171 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:SiGeBXG266UTiSiXG276X1 6.6407e-24
C_5_172 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:SiGeBXG267UTiSiXG276X1 1.8382e-27
C_5_173 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:SiGeBXG270UTiSiXG276X1 5.5014e-28
C_5_174 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:SiliconNXG281UTiSiXG277X1 4.4561e-24
C_5_175 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:n1g 8.9087e-20
C_5_176 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:n3d 1.1728e-22
C_5_177 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:n4s 1.1728e-22
C_5_178 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:p1g 3.0480e-23
C_5_179 iQ1:SiliconNXG279UTiSiXG274X1 iQ2:p2s 2.4681e-22
C_5_180 iQ1:n1d iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.2775e-18
C_5_181 iQ1:n1d iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.6835e-22
C_5_182 iQ1:n1d iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.4384e-23
C_5_183 iQ1:n1d iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.4817e-23
C_5_184 iQ1:n1d iQ2:SDexcludeXG247UTiSiXG276X1 5.8720e-21
C_5_185 iQ1:n1d iQ2:SDexcludeXG251UTiSiXG277X1 2.9452e-21
C_5_186 iQ1:n1d iQ2:SiGeBXG266UTiSiXG276X1 1.5400e-22
C_5_187 iQ1:n1d iQ2:SiGeBXG267UTiSiXG276X1 3.0516e-26
C_5_188 iQ1:n1d iQ2:SiGeBXG270UTiSiXG276X1 2.1906e-26
C_5_189 iQ1:n1d iQ2:SiliconNXG281UTiSiXG277X1 1.1586e-22
C_5_190 iQ1:n1d iQ2:n3d 3.0601e-21
C_5_191 iQ1:n1d iQ2:n4s 3.0601e-21
C_5_192 iQ1:n1d iQ2:p2s 6.0260e-21
C_5_193 iQ1:n2s iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.2775e-18
C_5_194 iQ1:n2s iQ2:LM00Cobalt2XG117USiGeBXG266X1 1.6835e-22
C_5_195 iQ1:n2s iQ2:LM00Cobalt2XG117UTiSiXG276X1 1.4384e-23
C_5_196 iQ1:n2s iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.4817e-23
C_5_197 iQ1:n2s iQ2:SDexcludeXG247UTiSiXG276X1 5.8720e-21
C_5_198 iQ1:n2s iQ2:SDexcludeXG251UTiSiXG277X1 2.9452e-21
C_5_199 iQ1:n2s iQ2:SiGeBXG266UTiSiXG276X1 1.5400e-22
C_5_200 iQ1:n2s iQ2:SiGeBXG267UTiSiXG276X1 3.0516e-26
C_5_201 iQ1:n2s iQ2:SiGeBXG270UTiSiXG276X1 2.1906e-26
C_5_202 iQ1:n2s iQ2:SiliconNXG281UTiSiXG277X1 1.1586e-22
C_5_203 iQ1:n2s iQ2:n3d 3.0601e-21
C_5_204 iQ1:n2s iQ2:n4s 3.0601e-21
C_5_205 iQ1:n2s iQ2:p2s 6.0260e-21
C_5_206 iQ1:n4g iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.4890e-19
C_5_207 iQ1:n4g iQ2:LM00Cobalt2XG117USiGeBXG266X1 9.2440e-20
C_5_208 iQ1:n4g iQ2:LM00Cobalt2XG117UTiSiXG276X1 9.2448e-20
C_5_209 iQ1:n4g iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.8122e-19
C_5_210 iQ1:n4g iQ2:SDexcludeXG247UTiSiXG276X1 8.0054e-24
C_5_211 iQ1:n4g iQ2:SDexcludeXG251UTiSiXG277X1 8.8777e-20
C_5_212 iQ1:n4g iQ2:SiGeBXG266UTiSiXG276X1 8.0054e-24
C_5_213 iQ1:n4g iQ2:SiGeBXG267UTiSiXG276X1 8.0054e-24
C_5_214 iQ1:n4g iQ2:SiGeBXG270UTiSiXG276X1 8.0054e-24
C_5_215 iQ1:n4g iQ2:SiliconNXG281UTiSiXG277X1 8.8777e-20
C_5_216 iQ1:n4g iQ2:n1g 4.1844e-21
C_5_217 iQ1:n4g iQ2:p1g 4.4314e-21
C_5_218 iQ1:p1d iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.8531e-18
C_5_219 iQ1:p1d iQ2:LM00Cobalt2XG117USiGeBXG266X1 4.3064e-20
C_5_220 iQ1:p1d iQ2:LM00Cobalt2XG117UTiSiXG276X1 3.0186e-21
C_5_221 iQ1:p1d iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.9615e-21
C_5_222 iQ1:p1d iQ2:SDexcludeXG247UTiSiXG276X1 3.7135e-20
C_5_223 iQ1:p1d iQ2:SDexcludeXG251UTiSiXG277X1 5.7732e-21
C_5_224 iQ1:p1d iQ2:SiGeBXG266UTiSiXG276X1 4.0161e-20
C_5_225 iQ1:p1d iQ2:SiGeBXG267UTiSiXG276X1 5.7992e-23
C_5_226 iQ1:p1d iQ2:SiGeBXG270UTiSiXG276X1 5.7989e-23
C_5_227 iQ1:p1d iQ2:SiliconNXG281UTiSiXG277X1 2.4277e-22
C_5_228 iQ1:p1d iQ2:n3d 6.0143e-21
C_5_229 iQ1:p1d iQ2:n4s 6.0143e-21
C_5_230 iQ1:p1d iQ2:p2s 7.7180e-20
C_5_231 iQ1:p2g iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 1.9935e-19
C_5_232 iQ1:p2g iQ2:LM00Cobalt2XG117USiGeBXG266X1 8.1400e-20
C_5_233 iQ1:p2g iQ2:LM00Cobalt2XG117UTiSiXG276X1 8.9033e-20
C_5_234 iQ1:p2g iQ2:LM00Cobalt2XG117UTiSiXG277X1 8.1429e-20
C_5_235 iQ1:p2g iQ2:SDexcludeXG247UTiSiXG276X1 7.6330e-21
C_5_236 iQ1:p2g iQ2:SDexcludeXG251UTiSiXG277X1 2.9144e-23
C_5_237 iQ1:p2g iQ2:SiGeBXG266UTiSiXG276X1 7.6330e-21
C_5_238 iQ1:p2g iQ2:SiGeBXG267UTiSiXG276X1 7.6330e-21
C_5_239 iQ1:p2g iQ2:SiGeBXG270UTiSiXG276X1 7.6330e-21
C_5_240 iQ1:p2g iQ2:SiliconNXG281UTiSiXG277X1 2.9144e-23
C_5_241 iQ1:p2g iQ2:n1g 4.4380e-21
C_5_242 iQ1:p2g iQ2:p1g 7.3070e-21
R_5_0 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ1:LM00Cobalt2XG280UTiSiXG274X1 1.2748e+02
R_5_1 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 5.9584e+01
R_5_2 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ1:n4g 1.9692e+03
R_5_3 iQ1:LM00Cobalt2XG280ULM10Tungsten1XG329X1 iQ1:p2g 6.3056e+01
R_5_4 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 0.0000e+00
R_5_5 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ1:SDexcludeXG246UTiSiXG275X1 3.3743e+04
R_5_6 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ1:SiGeBXG261UTiSiXG275X1 0.0000e+00
R_5_7 iQ1:LM00Cobalt2XG280USiGeBXG261X1 iQ1:p1d 2.4844e+03
R_5_8 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ1:LM00Cobalt2XG280UTiSiXG275X1 2.7429e+01
R_5_9 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ1:SDexcludeXG250UTiSiXG274X1 3.5678e+04
R_5_10 iQ1:LM00Cobalt2XG280UTiSiXG274X1 iQ1:SiliconNXG279UTiSiXG274X1 1.4446e+02
R_5_11 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ1:SDexcludeXG246UTiSiXG275X1 6.8278e+02
R_5_12 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ1:SiGeBXG261UTiSiXG275X1 0.0000e+00
R_5_13 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ1:SiGeBXG293UTiSiXG275X1 2.3601e+03
R_5_14 iQ1:LM00Cobalt2XG280UTiSiXG275X1 iQ1:SiGeBXG297UTiSiXG275X1 3.0759e+03
R_5_15 iQ1:SDexcludeXG246UTiSiXG275X1 iQ1:SiGeBXG261UTiSiXG275X1 0.0000e+00
R_5_16 iQ1:SDexcludeXG246UTiSiXG275X1 iQ1:SiGeBXG262UTiSiXG275X1 0.0000e+00
R_5_17 iQ1:SDexcludeXG246UTiSiXG275X1 iQ1:SiGeBXG265UTiSiXG275X1 0.0000e+00
R_5_18 iQ1:SDexcludeXG246UTiSiXG275X1 iQ1:SiGeBXG293UTiSiXG275X1 0.0000e+00
R_5_19 iQ1:SDexcludeXG246UTiSiXG275X1 iQ1:SiGeBXG297UTiSiXG275X1 0.0000e+00
R_5_20 iQ1:SDexcludeXG246UTiSiXG275X1 iQ1:p1d 5.1786e+03
R_5_21 iQ1:SDexcludeXG250UTiSiXG274X1 iQ1:SiliconNXG279UTiSiXG274X1 0.0000e+00
R_5_22 iQ1:SDexcludeXG250UTiSiXG274X1 iQ1:n1d 2.7791e+02
R_5_23 iQ1:SDexcludeXG250UTiSiXG274X1 iQ1:n2s 2.7791e+02
R_5_24 iQ1:SiGeBXG261UTiSiXG275X1 iQ1:SiGeBXG262UTiSiXG275X1 0.0000e+00
R_5_25 iQ1:SiGeBXG261UTiSiXG275X1 iQ1:SiGeBXG265UTiSiXG275X1 0.0000e+00
R_5_26 iQ1:SiGeBXG261UTiSiXG275X1 iQ1:SiGeBXG293UTiSiXG275X1 0.0000e+00
R_5_27 iQ1:SiGeBXG261UTiSiXG275X1 iQ1:SiGeBXG297UTiSiXG275X1 0.0000e+00
R_5_28 iQ1:SiGeBXG261UTiSiXG275X1 iQ1:p1d 2.4601e+01
R_5_29 iQ1:SiliconNXG279UTiSiXG274X1 iQ1:n1d 6.2309e+01
R_5_30 iQ1:SiliconNXG279UTiSiXG274X1 iQ1:n2s 6.2309e+01
R_5_31 iQ1:n1d iQ1:n2s 0.0000e+00
R_5_32 iQ1:n4g iQ1:p2g 5.7402e+01

*|NET iQ2 8.4277e-05PF
R_6_0 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 5.9712e+01
R_6_1 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 1.2690e+02
R_6_2 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 iQ2:n1g 1.9548e+03
R_6_3 iQ2:LM00Cobalt2XG117ULM10Tungsten1XG128X1 iQ2:p1g 6.3147e+01
R_6_4 iQ2:LM00Cobalt2XG117USiGeBXG266X1 iQ2:LM00Cobalt2XG117UTiSiXG276X1 0.0000e+00
R_6_5 iQ2:LM00Cobalt2XG117USiGeBXG266X1 iQ2:SDexcludeXG247UTiSiXG276X1 5.7168e+04
R_6_6 iQ2:LM00Cobalt2XG117USiGeBXG266X1 iQ2:SiGeBXG266UTiSiXG276X1 0.0000e+00
R_6_7 iQ2:LM00Cobalt2XG117USiGeBXG266X1 iQ2:p2s 2.6112e+03
R_6_8 iQ2:LM00Cobalt2XG117UTiSiXG276X1 iQ2:LM00Cobalt2XG117UTiSiXG277X1 2.7541e+01
R_6_9 iQ2:LM00Cobalt2XG117UTiSiXG276X1 iQ2:SDexcludeXG247UTiSiXG276X1 5.5606e+02
R_6_10 iQ2:LM00Cobalt2XG117UTiSiXG276X1 iQ2:SiGeBXG266UTiSiXG276X1 0.0000e+00
R_6_11 iQ2:LM00Cobalt2XG117UTiSiXG276X1 iQ2:SiGeBXG267UTiSiXG276X1 2.1991e+03
R_6_12 iQ2:LM00Cobalt2XG117UTiSiXG276X1 iQ2:SiGeBXG270UTiSiXG276X1 2.2027e+03
R_6_13 iQ2:LM00Cobalt2XG117UTiSiXG277X1 iQ2:SDexcludeXG251UTiSiXG277X1 3.5314e+04
R_6_14 iQ2:LM00Cobalt2XG117UTiSiXG277X1 iQ2:SiliconNXG281UTiSiXG277X1 1.5387e+02
R_6_15 iQ2:SDexcludeXG247UTiSiXG276X1 iQ2:SiGeBXG266UTiSiXG276X1 0.0000e+00
R_6_16 iQ2:SDexcludeXG247UTiSiXG276X1 iQ2:SiGeBXG267UTiSiXG276X1 0.0000e+00
R_6_17 iQ2:SDexcludeXG247UTiSiXG276X1 iQ2:SiGeBXG270UTiSiXG276X1 0.0000e+00
R_6_18 iQ2:SDexcludeXG247UTiSiXG276X1 iQ2:p2s 1.1001e+04
R_6_19 iQ2:SDexcludeXG251UTiSiXG277X1 iQ2:SiliconNXG281UTiSiXG277X1 0.0000e+00
R_6_20 iQ2:SDexcludeXG251UTiSiXG277X1 iQ2:n3d 2.7111e+02
R_6_21 iQ2:SDexcludeXG251UTiSiXG277X1 iQ2:n4s 2.7111e+02
R_6_22 iQ2:SiGeBXG266UTiSiXG276X1 iQ2:SiGeBXG267UTiSiXG276X1 0.0000e+00
R_6_23 iQ2:SiGeBXG266UTiSiXG276X1 iQ2:SiGeBXG270UTiSiXG276X1 0.0000e+00
R_6_24 iQ2:SiGeBXG266UTiSiXG276X1 iQ2:p2s 2.4522e+01
R_6_25 iQ2:SiliconNXG281UTiSiXG277X1 iQ2:n3d 6.2751e+01
R_6_26 iQ2:SiliconNXG281UTiSiXG277X1 iQ2:n4s 6.2751e+01
R_6_27 iQ2:n1g iQ2:p1g 5.7432e+01
R_6_28 iQ2:n3d iQ2:n4s 0.0000e+00

*|INSTANCES
XMP1 iQ1:p1d iQ2:p1g VDD:p1s VBP pmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMP1_delta/(1**0.5)'
XMP2 VDD:p2d iQ1:p2g iQ2:p2s VBP pmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMP2_delta/(1**0.5)'
XMN1 iQ1:n1d iQ2:n1g VSS:n1s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMN1_delta/(1**0.5)'
XMN2 BL:n2d WL:n2g iQ1:n2s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMN2_delta/(1**0.5)'
XMN3 iQ2:n3d WL:n3g BLB:n3s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMN3_delta/(1**0.5)'
XMN4 VSS:n4d iQ1:n4g iQ2:n4s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMN4_delta/(1**0.5)'

.ENDS array_flat
