*|TITLE Netlist generated by Raphael FX rcnetmerge
*|TITLE 1.1
*|TITLE Date Fri Apr 23 16:08:37 PDT 2021
*|PARAM cellnamefrom= raphaelfx
*|PARAM include= {}
*|PARAM instancefrom= raphaelnet
*|PARAM outputnet= n954_rph.spf
*|PARAM pingroup=  WL {WLL WLR} BL {BLU BLD} BLB {BLBU BLBD}
*|PARAM pinsfrom= raphaelfx
*|PARAM raphaelnet= n954_rph.spi
*|PARAM referencenet= /nfs/pdx/disks/icf_sandp_gwa001/changyok/swb/SNPS_DTCO/TRD2/20201220/BIC2022_update20210412/2-RC_Extraction/2.01-BIC2022_FinFET_PEX_Nominal/sram_hc_wide.lvs

.SUBCKT array BLBD BLBU BLD BLU VDD VSS WLL WLR VBP VBN

*|NETS BL BLB VDD VSS WL iQ1 iQ2

*|CAPACITANCE GRAND SUM 2.9146e-04PF
*|BLB WL 2.3629e-05PF
*|BLB iQ1 9.3558e-07PF
*|BLB iQ2 5.7236e-06PF
*|BL BLB 1.2792e-07PF
*|BL WL 2.3698e-05PF
*|BL iQ1 5.7896e-06PF
*|BL iQ2 9.3632e-07PF
*|VDD BL 8.7059e-06PF
*|VDD BLB 8.6753e-06PF
*|VDD VSS 1.1207e-05PF
*|VDD WL 8.2452e-06PF
*|VDD iQ1 1.4419e-05PF
*|VDD iQ2 1.4428e-05PF
*|VSS BL 8.7476e-06PF
*|VSS BLB 9.0658e-06PF
*|VSS WL 2.6160e-05PF
*|VSS iQ1 1.5215e-05PF
*|VSS iQ2 1.5228e-05PF
*|WL iQ1 2.0791e-05PF
*|WL iQ2 2.0466e-05PF
*|iQ1 iQ2 4.9270e-05PF

*|NET BL 4.8005e-05PF
C_0_0 BLBD BLD 7.6846e-22
C_0_1 BLBD BLU 7.6846e-22
C_0_2 BLBD BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 1.3805e-21
C_0_3 BLBD BL:LM00Cobalt2XG546UTiSiXG535X1 6.2067e-22
C_0_4 BLBD BL:SiliconNXG527UTiSiXG535X1 1.5906e-22
C_0_5 BLBD BL:n2d 2.9114e-22
C_0_6 BLBU BLD 7.6846e-22
C_0_7 BLBU BLU 7.6846e-22
C_0_8 BLBU BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 1.3805e-21
C_0_9 BLBU BL:LM00Cobalt2XG546UTiSiXG535X1 6.2067e-22
C_0_10 BLBU BL:SiliconNXG527UTiSiXG535X1 1.5906e-22
C_0_11 BLBU BL:n2d 2.9114e-22
C_0_12 BLD WLL 3.6205e-19
C_0_13 BLD WLR 3.6205e-19
C_0_14 BLD BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 1.3573e-21
C_0_15 BLD BLB:LM00Cobalt2XG70UTiSiXG71X1 5.9802e-22
C_0_16 BLD BLB:SiliconNXG72UTiSiXG71X1 1.6539e-22
C_0_17 BLD BLB:n3s 2.9828e-22
C_0_18 BLD WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 1.6175e-22
C_0_19 BLD WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.5875e-23
C_0_20 BLD WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 1.7331e-19
C_0_21 BLD WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 8.1947e-19
C_0_22 BLD WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 5.0442e-19
C_0_23 BLD WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 9.1400e-19
C_0_24 BLD WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 3.6205e-19
C_0_25 BLD WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.6039e-23
C_0_26 BLD WL:n2g 8.6560e-22
C_0_27 BLD WL:n3g 4.6245e-23
C_0_28 BLD iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 2.3172e-19
C_0_29 BLD iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.0969e-19
C_0_30 BLD iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.0969e-19
C_0_31 BLD iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.0967e-19
C_0_32 BLD iQ1:SDexcludeXG271UTiSiXG302X1 6.6502e-23
C_0_33 BLD iQ1:SDexcludeXG277UTiSiXG301X1 6.9461e-23
C_0_34 BLD iQ1:SDexcludeXG278UTiSiXG301X1 7.1355e-23
C_0_35 BLD iQ1:SiGeBXG291UTiSiXG302X1 1.7643e-23
C_0_36 BLD iQ1:SiGeBXG292UTiSiXG302X1 5.8650e-25
C_0_37 BLD iQ1:SiGeBXG331UTiSiXG302X1 5.8343e-25
C_0_38 BLD iQ1:SiGeBXG335UTiSiXG302X1 5.8341e-25
C_0_39 BLD iQ1:SiliconNXG308UTiSiXG301X1 4.6399e-23
C_0_40 BLD iQ1:n1d 1.2292e-22
C_0_41 BLD iQ1:n2s 1.2292e-22
C_0_42 BLD iQ1:n4g 4.1190e-23
C_0_43 BLD iQ1:p1d 8.2978e-23
C_0_44 BLD iQ1:p2g 7.2377e-23
C_0_45 BLD iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.8572e-19
C_0_46 BLD iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.6519e-22
C_0_47 BLD iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.6178e-22
C_0_48 BLD iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.6173e-22
C_0_49 BLD iQ2:SDexcludeXG272UTiSiXG305X1 3.9561e-23
C_0_50 BLD iQ2:SDexcludeXG279UTiSiXG306X1 1.6382e-23
C_0_51 BLD iQ2:SDexcludeXG280UTiSiXG306X1 1.4300e-23
C_0_52 BLD iQ2:SiGeBXG294UTiSiXG305X1 3.5450e-24
C_0_53 BLD iQ2:SiGeBXG296UTiSiXG305X1 6.5797e-26
C_0_54 BLD iQ2:SiGeBXG336UTiSiXG305X1 6.2780e-26
C_0_55 BLD iQ2:SiliconNXG311UTiSiXG306X1 1.0328e-24
C_0_56 BLD iQ2:n1g 6.8306e-22
C_0_57 BLD iQ2:n3d 3.1672e-23
C_0_58 BLD iQ2:n4s 3.1672e-23
C_0_59 BLD iQ2:p1g 1.3906e-22
C_0_60 BLD iQ2:p2s 4.2981e-23
C_0_61 BLU WLL 3.6205e-19
C_0_62 BLU WLR 3.6205e-19
C_0_63 BLU BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 1.3573e-21
C_0_64 BLU BLB:LM00Cobalt2XG70UTiSiXG71X1 5.9802e-22
C_0_65 BLU BLB:SiliconNXG72UTiSiXG71X1 1.6539e-22
C_0_66 BLU BLB:n3s 2.9828e-22
C_0_67 BLU WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 1.6175e-22
C_0_68 BLU WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.5875e-23
C_0_69 BLU WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 1.7331e-19
C_0_70 BLU WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 8.1947e-19
C_0_71 BLU WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 5.0442e-19
C_0_72 BLU WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 9.1400e-19
C_0_73 BLU WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 3.6205e-19
C_0_74 BLU WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.6039e-23
C_0_75 BLU WL:n2g 8.6560e-22
C_0_76 BLU WL:n3g 4.6245e-23
C_0_77 BLU iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 2.3172e-19
C_0_78 BLU iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.0969e-19
C_0_79 BLU iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.0969e-19
C_0_80 BLU iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.0967e-19
C_0_81 BLU iQ1:SDexcludeXG271UTiSiXG302X1 6.6502e-23
C_0_82 BLU iQ1:SDexcludeXG277UTiSiXG301X1 6.9461e-23
C_0_83 BLU iQ1:SDexcludeXG278UTiSiXG301X1 7.1355e-23
C_0_84 BLU iQ1:SiGeBXG291UTiSiXG302X1 1.7643e-23
C_0_85 BLU iQ1:SiGeBXG292UTiSiXG302X1 5.8650e-25
C_0_86 BLU iQ1:SiGeBXG331UTiSiXG302X1 5.8343e-25
C_0_87 BLU iQ1:SiGeBXG335UTiSiXG302X1 5.8341e-25
C_0_88 BLU iQ1:SiliconNXG308UTiSiXG301X1 4.6399e-23
C_0_89 BLU iQ1:n1d 1.2292e-22
C_0_90 BLU iQ1:n2s 1.2292e-22
C_0_91 BLU iQ1:n4g 4.1190e-23
C_0_92 BLU iQ1:p1d 8.2978e-23
C_0_93 BLU iQ1:p2g 7.2377e-23
C_0_94 BLU iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.8572e-19
C_0_95 BLU iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.6519e-22
C_0_96 BLU iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.6178e-22
C_0_97 BLU iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.6173e-22
C_0_98 BLU iQ2:SDexcludeXG272UTiSiXG305X1 3.9561e-23
C_0_99 BLU iQ2:SDexcludeXG279UTiSiXG306X1 1.6382e-23
C_0_100 BLU iQ2:SDexcludeXG280UTiSiXG306X1 1.4300e-23
C_0_101 BLU iQ2:SiGeBXG294UTiSiXG305X1 3.5450e-24
C_0_102 BLU iQ2:SiGeBXG296UTiSiXG305X1 6.5797e-26
C_0_103 BLU iQ2:SiGeBXG336UTiSiXG305X1 6.2780e-26
C_0_104 BLU iQ2:SiliconNXG311UTiSiXG306X1 1.0328e-24
C_0_105 BLU iQ2:n1g 6.8306e-22
C_0_106 BLU iQ2:n3d 3.1672e-23
C_0_107 BLU iQ2:n4s 3.1672e-23
C_0_108 BLU iQ2:p1g 1.3906e-22
C_0_109 BLU iQ2:p2s 4.2981e-23
C_0_110 WLL BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 3.6335e-19
C_0_111 WLL BL:LM00Cobalt2XG546UTiSiXG535X1 1.3063e-21
C_0_112 WLL BL:SiliconNXG527UTiSiXG535X1 1.5029e-22
C_0_113 WLL BL:n2d 1.6168e-22
C_0_114 WLR BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 3.6335e-19
C_0_115 WLR BL:LM00Cobalt2XG546UTiSiXG535X1 1.3063e-21
C_0_116 WLR BL:SiliconNXG527UTiSiXG535X1 1.5029e-22
C_0_117 WLR BL:n2d 1.6168e-22
C_0_118 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 1.9902e-21
C_0_119 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 6.2021e-22
C_0_120 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 BLB:SiliconNXG72UTiSiXG71X1 3.4923e-22
C_0_121 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 BLB:n3s 1.6537e-21
C_0_122 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 8.5414e-22
C_0_123 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.7319e-23
C_0_124 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 2.2355e-18
C_0_125 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 1.1053e-18
C_0_126 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 5.1257e-19
C_0_127 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.0052e-18
C_0_128 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 3.6335e-19
C_0_129 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.6619e-23
C_0_130 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 WL:n2g 1.8393e-19
C_0_131 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 WL:n3g 5.1450e-22
C_0_132 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 7.4432e-19
C_0_133 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.8871e-19
C_0_134 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.8829e-19
C_0_135 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.8822e-19
C_0_136 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:SDexcludeXG271UTiSiXG302X1 1.1689e-21
C_0_137 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:SDexcludeXG277UTiSiXG301X1 6.4681e-22
C_0_138 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:SDexcludeXG278UTiSiXG301X1 7.3757e-22
C_0_139 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:SiGeBXG291UTiSiXG302X1 4.9796e-22
C_0_140 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:SiGeBXG292UTiSiXG302X1 5.7672e-24
C_0_141 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:SiGeBXG331UTiSiXG302X1 5.7644e-24
C_0_142 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:SiGeBXG335UTiSiXG302X1 5.7641e-24
C_0_143 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:SiliconNXG308UTiSiXG301X1 3.6061e-22
C_0_144 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:n1d 1.5448e-21
C_0_145 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:n2s 1.5448e-21
C_0_146 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:n4g 6.6696e-22
C_0_147 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:p1d 1.6553e-21
C_0_148 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ1:p2g 1.4086e-21
C_0_149 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.8933e-19
C_0_150 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 3.9418e-22
C_0_151 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 3.7531e-22
C_0_152 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 3.7522e-22
C_0_153 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:SDexcludeXG272UTiSiXG305X1 6.0784e-22
C_0_154 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:SDexcludeXG279UTiSiXG306X1 2.4381e-22
C_0_155 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:SDexcludeXG280UTiSiXG306X1 2.1529e-22
C_0_156 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:SiGeBXG294UTiSiXG305X1 1.9138e-23
C_0_157 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:SiGeBXG296UTiSiXG305X1 1.4294e-25
C_0_158 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:SiGeBXG336UTiSiXG305X1 1.3757e-25
C_0_159 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:SiliconNXG311UTiSiXG306X1 1.3274e-23
C_0_160 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:n1g 1.5241e-21
C_0_161 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:n3d 4.7225e-22
C_0_162 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:n4s 4.7225e-22
C_0_163 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:p1g 5.2101e-22
C_0_164 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 iQ2:p2s 6.2670e-22
C_0_165 BL:LM00Cobalt2XG546UTiSiXG535X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 6.4275e-22
C_0_166 BL:LM00Cobalt2XG546UTiSiXG535X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 2.3552e-23
C_0_167 BL:LM00Cobalt2XG546UTiSiXG535X1 BLB:SiliconNXG72UTiSiXG71X1 1.9513e-22
C_0_168 BL:LM00Cobalt2XG546UTiSiXG535X1 BLB:n3s 1.4385e-21
C_0_169 BL:LM00Cobalt2XG546UTiSiXG535X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 7.3449e-22
C_0_170 BL:LM00Cobalt2XG546UTiSiXG535X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.5276e-24
C_0_171 BL:LM00Cobalt2XG546UTiSiXG535X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 2.0750e-18
C_0_172 BL:LM00Cobalt2XG546UTiSiXG535X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 2.8704e-19
C_0_173 BL:LM00Cobalt2XG546UTiSiXG535X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 8.2003e-21
C_0_174 BL:LM00Cobalt2XG546UTiSiXG535X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 9.1594e-20
C_0_175 BL:LM00Cobalt2XG546UTiSiXG535X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 1.3063e-21
C_0_176 BL:LM00Cobalt2XG546UTiSiXG535X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 6.1079e-25
C_0_177 BL:LM00Cobalt2XG546UTiSiXG535X1 WL:n2g 1.8784e-19
C_0_178 BL:LM00Cobalt2XG546UTiSiXG535X1 WL:n3g 4.9673e-22
C_0_179 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 5.2029e-19
C_0_180 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 7.9218e-20
C_0_181 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 7.8780e-20
C_0_182 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 7.8739e-20
C_0_183 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:SDexcludeXG271UTiSiXG302X1 1.1621e-21
C_0_184 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:SDexcludeXG277UTiSiXG301X1 6.1320e-22
C_0_185 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:SDexcludeXG278UTiSiXG301X1 7.0504e-22
C_0_186 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:SiGeBXG291UTiSiXG302X1 4.8914e-22
C_0_187 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:SiGeBXG292UTiSiXG302X1 5.2278e-24
C_0_188 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:SiGeBXG331UTiSiXG302X1 5.2280e-24
C_0_189 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:SiGeBXG335UTiSiXG302X1 5.2278e-24
C_0_190 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:SiliconNXG308UTiSiXG301X1 3.2068e-22
C_0_191 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:n1d 1.5020e-21
C_0_192 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:n2s 1.5020e-21
C_0_193 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:n4g 6.6120e-22
C_0_194 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:p1d 1.6408e-21
C_0_195 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ1:p2g 1.3974e-21
C_0_196 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 3.8011e-21
C_0_197 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 1.3100e-22
C_0_198 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 1.1473e-22
C_0_199 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 1.1468e-22
C_0_200 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:SDexcludeXG272UTiSiXG305X1 6.0136e-22
C_0_201 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:SDexcludeXG279UTiSiXG306X1 2.4096e-22
C_0_202 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:SDexcludeXG280UTiSiXG306X1 2.1308e-22
C_0_203 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:SiGeBXG294UTiSiXG305X1 1.6420e-23
C_0_204 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:SiGeBXG296UTiSiXG305X1 7.8016e-26
C_0_205 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:SiGeBXG336UTiSiXG305X1 7.5565e-26
C_0_206 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:SiliconNXG311UTiSiXG306X1 1.2971e-23
C_0_207 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:n1g 8.9547e-22
C_0_208 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:n3d 4.6693e-22
C_0_209 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:n4s 4.6693e-22
C_0_210 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:p1g 4.0525e-22
C_0_211 BL:LM00Cobalt2XG546UTiSiXG535X1 iQ2:p2s 6.1763e-22
C_0_212 BL:SiliconNXG527UTiSiXG535X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 3.3246e-22
C_0_213 BL:SiliconNXG527UTiSiXG535X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 1.8504e-22
C_0_214 BL:SiliconNXG527UTiSiXG535X1 BLB:SiliconNXG72UTiSiXG71X1 1.5207e-21
C_0_215 BL:SiliconNXG527UTiSiXG535X1 BLB:n3s 1.1107e-20
C_0_216 BL:SiliconNXG527UTiSiXG535X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 5.5403e-21
C_0_217 BL:SiliconNXG527UTiSiXG535X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.1243e-23
C_0_218 BL:SiliconNXG527UTiSiXG535X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 2.2402e-18
C_0_219 BL:SiliconNXG527UTiSiXG535X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 7.6892e-20
C_0_220 BL:SiliconNXG527UTiSiXG535X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 1.3266e-21
C_0_221 BL:SiliconNXG527UTiSiXG535X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.2000e-20
C_0_222 BL:SiliconNXG527UTiSiXG535X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 1.5037e-22
C_0_223 BL:SiliconNXG527UTiSiXG535X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 4.0264e-24
C_0_224 BL:SiliconNXG527UTiSiXG535X1 WL:n2g 4.7774e-21
C_0_225 BL:SiliconNXG527UTiSiXG535X1 WL:n3g 2.8476e-23
C_0_226 BL:SiliconNXG527UTiSiXG535X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 2.7617e-19
C_0_227 BL:SiliconNXG527UTiSiXG535X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 4.2859e-21
C_0_228 BL:SiliconNXG527UTiSiXG535X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 3.5158e-21
C_0_229 BL:SiliconNXG527UTiSiXG535X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 3.4982e-21
C_0_230 BL:SiliconNXG527UTiSiXG535X1 iQ1:SDexcludeXG271UTiSiXG302X1 7.2553e-21
C_0_231 BL:SiliconNXG527UTiSiXG535X1 iQ1:SDexcludeXG277UTiSiXG301X1 6.5781e-21
C_0_232 BL:SiliconNXG527UTiSiXG535X1 iQ1:SDexcludeXG278UTiSiXG301X1 6.1402e-21
C_0_233 BL:SiliconNXG527UTiSiXG535X1 iQ1:SiGeBXG291UTiSiXG302X1 7.9292e-22
C_0_234 BL:SiliconNXG527UTiSiXG535X1 iQ1:SiGeBXG292UTiSiXG302X1 2.6206e-24
C_0_235 BL:SiliconNXG527UTiSiXG535X1 iQ1:SiGeBXG331UTiSiXG302X1 2.6193e-24
C_0_236 BL:SiliconNXG527UTiSiXG535X1 iQ1:SiGeBXG335UTiSiXG302X1 2.6159e-24
C_0_237 BL:SiliconNXG527UTiSiXG535X1 iQ1:SiliconNXG308UTiSiXG301X1 7.1705e-22
C_0_238 BL:SiliconNXG527UTiSiXG535X1 iQ1:n1d 1.3375e-20
C_0_239 BL:SiliconNXG527UTiSiXG535X1 iQ1:n2s 1.3375e-20
C_0_240 BL:SiliconNXG527UTiSiXG535X1 iQ1:n4g 3.5427e-23
C_0_241 BL:SiliconNXG527UTiSiXG535X1 iQ1:p1d 8.0430e-21
C_0_242 BL:SiliconNXG527UTiSiXG535X1 iQ1:p2g 6.1170e-23
C_0_243 BL:SiliconNXG527UTiSiXG535X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.3332e-20
C_0_244 BL:SiliconNXG527UTiSiXG535X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 1.2361e-22
C_0_245 BL:SiliconNXG527UTiSiXG535X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.6279e-23
C_0_246 BL:SiliconNXG527UTiSiXG535X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.6452e-23
C_0_247 BL:SiliconNXG527UTiSiXG535X1 iQ2:SDexcludeXG272UTiSiXG305X1 3.9004e-21
C_0_248 BL:SiliconNXG527UTiSiXG535X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.7084e-21
C_0_249 BL:SiliconNXG527UTiSiXG535X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.5623e-21
C_0_250 BL:SiliconNXG527UTiSiXG535X1 iQ2:SiGeBXG294UTiSiXG305X1 9.7361e-23
C_0_251 BL:SiliconNXG527UTiSiXG535X1 iQ2:SiGeBXG296UTiSiXG305X1 3.1480e-26
C_0_252 BL:SiliconNXG527UTiSiXG535X1 iQ2:SiGeBXG336UTiSiXG305X1 1.7864e-26
C_0_253 BL:SiliconNXG527UTiSiXG535X1 iQ2:SiliconNXG311UTiSiXG306X1 9.2581e-23
C_0_254 BL:SiliconNXG527UTiSiXG535X1 iQ2:n1g 5.4398e-23
C_0_255 BL:SiliconNXG527UTiSiXG535X1 iQ2:n3d 3.3627e-21
C_0_256 BL:SiliconNXG527UTiSiXG535X1 iQ2:n4s 3.3627e-21
C_0_257 BL:SiliconNXG527UTiSiXG535X1 iQ2:p1g 2.3301e-23
C_0_258 BL:SiliconNXG527UTiSiXG535X1 iQ2:p2s 3.9977e-21
C_0_259 BL:n2d BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 1.5727e-21
C_0_260 BL:n2d BLB:LM00Cobalt2XG70UTiSiXG71X1 1.3674e-21
C_0_261 BL:n2d BLB:SiliconNXG72UTiSiXG71X1 1.1138e-20
C_0_262 BL:n2d BLB:n3s 8.0972e-20
C_0_263 BL:n2d WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 4.0050e-20
C_0_264 BL:n2d WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 8.2039e-23
C_0_265 BL:n2d WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 5.4318e-18
C_0_266 BL:n2d WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 8.4106e-20
C_0_267 BL:n2d WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 1.4047e-21
C_0_268 BL:n2d WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.2730e-20
C_0_269 BL:n2d WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 1.6223e-22
C_0_270 BL:n2d WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 2.9311e-23
C_0_271 BL:n2d iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 5.8911e-19
C_0_272 BL:n2d iQ1:LM00Cobalt2XG314USiGeBXG291X1 6.6276e-21
C_0_273 BL:n2d iQ1:LM00Cobalt2XG314UTiSiXG301X1 4.2711e-21
C_0_274 BL:n2d iQ1:LM00Cobalt2XG314UTiSiXG302X1 4.2393e-21
C_0_275 BL:n2d iQ1:SDexcludeXG271UTiSiXG302X1 5.0684e-20
C_0_276 BL:n2d iQ1:SDexcludeXG277UTiSiXG301X1 1.0550e-19
C_0_277 BL:n2d iQ1:SDexcludeXG278UTiSiXG301X1 9.8841e-20
C_0_278 BL:n2d iQ1:SiGeBXG291UTiSiXG302X1 2.3948e-21
C_0_279 BL:n2d iQ1:SiGeBXG292UTiSiXG302X1 3.2834e-24
C_0_280 BL:n2d iQ1:SiGeBXG331UTiSiXG302X1 3.2976e-24
C_0_281 BL:n2d iQ1:SiGeBXG335UTiSiXG302X1 3.2713e-24
C_0_282 BL:n2d iQ1:SiliconNXG308UTiSiXG301X1 4.2363e-21
C_0_283 BL:n2d iQ1:n1d 2.0847e-19
C_0_284 BL:n2d iQ1:n2s 2.0847e-19
C_0_285 BL:n2d iQ1:p1d 5.3073e-20
C_0_286 BL:n2d iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.8925e-19
C_0_287 BL:n2d iQ2:LM00Cobalt2XG151USiGeBXG294X1 7.5468e-22
C_0_288 BL:n2d iQ2:LM00Cobalt2XG151UTiSiXG305X1 8.6290e-23
C_0_289 BL:n2d iQ2:LM00Cobalt2XG151UTiSiXG306X1 8.7577e-23
C_0_290 BL:n2d iQ2:SDexcludeXG272UTiSiXG305X1 2.6550e-20
C_0_291 BL:n2d iQ2:SDexcludeXG279UTiSiXG306X1 1.2080e-20
C_0_292 BL:n2d iQ2:SDexcludeXG280UTiSiXG306X1 1.1173e-20
C_0_293 BL:n2d iQ2:SiGeBXG294UTiSiXG305X1 6.6850e-22
C_0_294 BL:n2d iQ2:SiGeBXG296UTiSiXG305X1 1.0788e-25
C_0_295 BL:n2d iQ2:SiGeBXG336UTiSiXG305X1 6.0927e-26
C_0_296 BL:n2d iQ2:SiliconNXG311UTiSiXG306X1 6.5622e-22
C_0_297 BL:n2d iQ2:n3d 2.3906e-20
C_0_298 BL:n2d iQ2:n4s 2.3906e-20
C_0_299 BL:n2d iQ2:p2s 2.7219e-20
R_0_0 BLD BLU 1.1537e+01
R_0_1 BLD BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 3.3910e+01
R_0_2 BLU BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 1.0187e+03
R_0_3 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 BL:LM00Cobalt2XG546UTiSiXG535X1 5.7614e+01
R_0_4 BL:LM00Cobalt2XG546UTiSiXG535X1 BL:SiliconNXG527UTiSiXG535X1 1.7735e+02
R_0_5 BL:SiliconNXG527UTiSiXG535X1 BL:n2d 2.1217e+01

*|NET BLB 4.8157e-05PF
C_1_0 BLBD WLL 3.6273e-19
C_1_1 BLBD WLR 3.6273e-19
C_1_2 BLBD WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 1.6861e-19
C_1_3 BLBD WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 8.2779e-19
C_1_4 BLBD WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 1.5497e-22
C_1_5 BLBD WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 1.0941e-23
C_1_6 BLBD WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 3.6274e-19
C_1_7 BLBD WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.2372e-23
C_1_8 BLBD WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 4.7442e-19
C_1_9 BLBD WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 8.9612e-19
C_1_10 BLBD WL:n2g 4.5572e-23
C_1_11 BLBD WL:n3g 8.4353e-22
C_1_12 BLBD iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 1.8571e-19
C_1_13 BLBD iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.6287e-22
C_1_14 BLBD iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.5943e-22
C_1_15 BLBD iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.5946e-22
C_1_16 BLBD iQ1:SDexcludeXG271UTiSiXG302X1 3.9382e-23
C_1_17 BLBD iQ1:SDexcludeXG277UTiSiXG301X1 1.4165e-23
C_1_18 BLBD iQ1:SDexcludeXG278UTiSiXG301X1 1.6241e-23
C_1_19 BLBD iQ1:SiGeBXG291UTiSiXG302X1 3.5138e-24
C_1_20 BLBD iQ1:SiGeBXG292UTiSiXG302X1 5.2062e-26
C_1_21 BLBD iQ1:SiGeBXG331UTiSiXG302X1 5.0244e-26
C_1_22 BLBD iQ1:SiGeBXG335UTiSiXG302X1 5.0222e-26
C_1_23 BLBD iQ1:SiliconNXG308UTiSiXG301X1 1.0261e-24
C_1_24 BLBD iQ1:n1d 3.1387e-23
C_1_25 BLBD iQ1:n2s 3.1387e-23
C_1_26 BLBD iQ1:n4g 6.8597e-22
C_1_27 BLBD iQ1:p1d 4.2795e-23
C_1_28 BLBD iQ1:p2g 1.3856e-22
C_1_29 BLBD iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.3256e-19
C_1_30 BLBD iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.0985e-19
C_1_31 BLBD iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.0983e-19
C_1_32 BLBD iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.0985e-19
C_1_33 BLBD iQ2:SDexcludeXG272UTiSiXG305X1 6.6255e-23
C_1_34 BLBD iQ2:SDexcludeXG279UTiSiXG306X1 7.3194e-23
C_1_35 BLBD iQ2:SDexcludeXG280UTiSiXG306X1 7.1314e-23
C_1_36 BLBD iQ2:SiGeBXG294UTiSiXG305X1 1.8189e-23
C_1_37 BLBD iQ2:SiGeBXG296UTiSiXG305X1 6.3709e-25
C_1_38 BLBD iQ2:SiGeBXG336UTiSiXG305X1 6.3792e-25
C_1_39 BLBD iQ2:SiliconNXG311UTiSiXG306X1 5.9216e-23
C_1_40 BLBD iQ2:n1g 4.0997e-23
C_1_41 BLBD iQ2:n3d 1.3216e-22
C_1_42 BLBD iQ2:n4s 1.3216e-22
C_1_43 BLBD iQ2:p1g 7.3013e-23
C_1_44 BLBD iQ2:p2s 8.3171e-23
C_1_45 BLBU WLL 3.6273e-19
C_1_46 BLBU WLR 3.6273e-19
C_1_47 BLBU WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 1.6861e-19
C_1_48 BLBU WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 8.2779e-19
C_1_49 BLBU WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 1.5497e-22
C_1_50 BLBU WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 1.0941e-23
C_1_51 BLBU WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 3.6274e-19
C_1_52 BLBU WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.2372e-23
C_1_53 BLBU WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 4.7442e-19
C_1_54 BLBU WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 8.9612e-19
C_1_55 BLBU WL:n2g 4.5572e-23
C_1_56 BLBU WL:n3g 8.4353e-22
C_1_57 BLBU iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 1.8571e-19
C_1_58 BLBU iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.6287e-22
C_1_59 BLBU iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.5943e-22
C_1_60 BLBU iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.5946e-22
C_1_61 BLBU iQ1:SDexcludeXG271UTiSiXG302X1 3.9382e-23
C_1_62 BLBU iQ1:SDexcludeXG277UTiSiXG301X1 1.4165e-23
C_1_63 BLBU iQ1:SDexcludeXG278UTiSiXG301X1 1.6241e-23
C_1_64 BLBU iQ1:SiGeBXG291UTiSiXG302X1 3.5138e-24
C_1_65 BLBU iQ1:SiGeBXG292UTiSiXG302X1 5.2062e-26
C_1_66 BLBU iQ1:SiGeBXG331UTiSiXG302X1 5.0244e-26
C_1_67 BLBU iQ1:SiGeBXG335UTiSiXG302X1 5.0222e-26
C_1_68 BLBU iQ1:SiliconNXG308UTiSiXG301X1 1.0261e-24
C_1_69 BLBU iQ1:n1d 3.1387e-23
C_1_70 BLBU iQ1:n2s 3.1387e-23
C_1_71 BLBU iQ1:n4g 6.8597e-22
C_1_72 BLBU iQ1:p1d 4.2795e-23
C_1_73 BLBU iQ1:p2g 1.3856e-22
C_1_74 BLBU iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.3256e-19
C_1_75 BLBU iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.0985e-19
C_1_76 BLBU iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.0983e-19
C_1_77 BLBU iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.0985e-19
C_1_78 BLBU iQ2:SDexcludeXG272UTiSiXG305X1 6.6255e-23
C_1_79 BLBU iQ2:SDexcludeXG279UTiSiXG306X1 7.3194e-23
C_1_80 BLBU iQ2:SDexcludeXG280UTiSiXG306X1 7.1314e-23
C_1_81 BLBU iQ2:SiGeBXG294UTiSiXG305X1 1.8189e-23
C_1_82 BLBU iQ2:SiGeBXG296UTiSiXG305X1 6.3709e-25
C_1_83 BLBU iQ2:SiGeBXG336UTiSiXG305X1 6.3792e-25
C_1_84 BLBU iQ2:SiliconNXG311UTiSiXG306X1 5.9216e-23
C_1_85 BLBU iQ2:n1g 4.0997e-23
C_1_86 BLBU iQ2:n3d 1.3216e-22
C_1_87 BLBU iQ2:n4s 1.3216e-22
C_1_88 BLBU iQ2:p1g 7.3013e-23
C_1_89 BLBU iQ2:p2s 8.3171e-23
C_1_90 WLL BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 3.6393e-19
C_1_91 WLL BLB:LM00Cobalt2XG70UTiSiXG71X1 1.2037e-21
C_1_92 WLL BLB:SiliconNXG72UTiSiXG71X1 1.3595e-22
C_1_93 WLL BLB:n3s 1.4651e-22
C_1_94 WLR BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 3.6393e-19
C_1_95 WLR BLB:LM00Cobalt2XG70UTiSiXG71X1 1.2037e-21
C_1_96 WLR BLB:SiliconNXG72UTiSiXG71X1 1.3595e-22
C_1_97 WLR BLB:n3s 1.4651e-22
C_1_98 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 2.2034e-18
C_1_99 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.1382e-18
C_1_100 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 8.0944e-22
C_1_101 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 1.2256e-23
C_1_102 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 3.6393e-19
C_1_103 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.2860e-23
C_1_104 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 4.7791e-19
C_1_105 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.0131e-18
C_1_106 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 WL:n2g 4.8779e-22
C_1_107 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 WL:n3g 1.8202e-19
C_1_108 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 1.8913e-19
C_1_109 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 3.8530e-22
C_1_110 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 3.6728e-22
C_1_111 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 3.6734e-22
C_1_112 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:SDexcludeXG271UTiSiXG302X1 5.7526e-22
C_1_113 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:SDexcludeXG277UTiSiXG301X1 2.0400e-22
C_1_114 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:SDexcludeXG278UTiSiXG301X1 2.3086e-22
C_1_115 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:SiGeBXG291UTiSiXG302X1 1.8178e-23
C_1_116 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:SiGeBXG292UTiSiXG302X1 1.0917e-25
C_1_117 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:SiGeBXG331UTiSiXG302X1 1.0673e-25
C_1_118 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:SiGeBXG335UTiSiXG302X1 1.0647e-25
C_1_119 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:SiliconNXG308UTiSiXG301X1 1.2670e-23
C_1_120 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:n1d 4.4738e-22
C_1_121 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:n2s 4.4738e-22
C_1_122 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:n4g 1.4853e-21
C_1_123 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:p1d 5.9323e-22
C_1_124 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ1:p2g 5.0084e-22
C_1_125 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 7.0915e-19
C_1_126 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.8622e-19
C_1_127 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.8578e-19
C_1_128 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.8584e-19
C_1_129 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:SDexcludeXG272UTiSiXG305X1 1.0952e-21
C_1_130 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:SDexcludeXG279UTiSiXG306X1 7.0266e-22
C_1_131 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:SDexcludeXG280UTiSiXG306X1 6.2215e-22
C_1_132 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:SiGeBXG294UTiSiXG305X1 4.5459e-22
C_1_133 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:SiGeBXG296UTiSiXG305X1 5.7027e-24
C_1_134 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:SiGeBXG336UTiSiXG305X1 5.7023e-24
C_1_135 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:SiliconNXG311UTiSiXG306X1 3.4428e-22
C_1_136 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:n1g 6.3090e-22
C_1_137 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:n3d 1.4722e-21
C_1_138 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:n4s 1.4722e-21
C_1_139 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:p1g 1.3216e-21
C_1_140 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 iQ2:p2s 1.5384e-21
C_1_141 BLB:LM00Cobalt2XG70UTiSiXG71X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 2.0481e-18
C_1_142 BLB:LM00Cobalt2XG70UTiSiXG71X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 3.1181e-19
C_1_143 BLB:LM00Cobalt2XG70UTiSiXG71X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 6.9800e-22
C_1_144 BLB:LM00Cobalt2XG70UTiSiXG71X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 1.3952e-24
C_1_145 BLB:LM00Cobalt2XG70UTiSiXG71X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 1.2037e-21
C_1_146 BLB:LM00Cobalt2XG70UTiSiXG71X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 5.1345e-25
C_1_147 BLB:LM00Cobalt2XG70UTiSiXG71X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 3.5086e-21
C_1_148 BLB:LM00Cobalt2XG70UTiSiXG71X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.1748e-19
C_1_149 BLB:LM00Cobalt2XG70UTiSiXG71X1 WL:n2g 4.7163e-22
C_1_150 BLB:LM00Cobalt2XG70UTiSiXG71X1 WL:n3g 1.8588e-19
C_1_151 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 3.6263e-21
C_1_152 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.2457e-22
C_1_153 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 1.0914e-22
C_1_154 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 1.0916e-22
C_1_155 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:SDexcludeXG271UTiSiXG302X1 5.7027e-22
C_1_156 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:SDexcludeXG277UTiSiXG301X1 2.0235e-22
C_1_157 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:SDexcludeXG278UTiSiXG301X1 2.2863e-22
C_1_158 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:SiGeBXG291UTiSiXG302X1 1.5521e-23
C_1_159 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:SiGeBXG292UTiSiXG302X1 5.7833e-26
C_1_160 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:SiGeBXG331UTiSiXG302X1 5.7159e-26
C_1_161 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:SiGeBXG335UTiSiXG302X1 5.6899e-26
C_1_162 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:SiliconNXG308UTiSiXG301X1 1.2405e-23
C_1_163 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:n1d 4.4326e-22
C_1_164 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:n2s 4.4326e-22
C_1_165 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:n4g 8.5525e-22
C_1_166 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:p1d 5.8568e-22
C_1_167 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ1:p2g 3.8652e-22
C_1_168 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 4.8529e-19
C_1_169 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 7.6598e-20
C_1_170 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 7.6161e-20
C_1_171 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 7.6199e-20
C_1_172 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:SDexcludeXG272UTiSiXG305X1 1.0913e-21
C_1_173 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:SDexcludeXG279UTiSiXG306X1 6.6962e-22
C_1_174 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:SDexcludeXG280UTiSiXG306X1 5.8758e-22
C_1_175 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:SiGeBXG294UTiSiXG305X1 4.4696e-22
C_1_176 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:SiGeBXG296UTiSiXG305X1 5.1289e-24
C_1_177 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:SiGeBXG336UTiSiXG305X1 5.1276e-24
C_1_178 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:SiliconNXG311UTiSiXG306X1 2.9253e-22
C_1_179 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:n1g 6.2664e-22
C_1_180 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:n3d 1.4231e-21
C_1_181 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:n4s 1.4231e-21
C_1_182 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:p1g 1.3129e-21
C_1_183 BLB:LM00Cobalt2XG70UTiSiXG71X1 iQ2:p2s 1.5280e-21
C_1_184 BLB:SiliconNXG72UTiSiXG71X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 2.2435e-18
C_1_185 BLB:SiliconNXG72UTiSiXG71X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 8.0961e-20
C_1_186 BLB:SiliconNXG72UTiSiXG71X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 5.5565e-21
C_1_187 BLB:SiliconNXG72UTiSiXG71X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 1.0313e-23
C_1_188 BLB:SiliconNXG72UTiSiXG71X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 1.3629e-22
C_1_189 BLB:SiliconNXG72UTiSiXG71X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 3.0838e-24
C_1_190 BLB:SiliconNXG72UTiSiXG71X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 5.1310e-22
C_1_191 BLB:SiliconNXG72UTiSiXG71X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.6169e-20
C_1_192 BLB:SiliconNXG72UTiSiXG71X1 WL:n2g 2.9415e-23
C_1_193 BLB:SiliconNXG72UTiSiXG71X1 WL:n3g 4.7002e-21
C_1_194 BLB:SiliconNXG72UTiSiXG71X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 2.3384e-20
C_1_195 BLB:SiliconNXG72UTiSiXG71X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.2393e-22
C_1_196 BLB:SiliconNXG72UTiSiXG71X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.6780e-23
C_1_197 BLB:SiliconNXG72UTiSiXG71X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.6506e-23
C_1_198 BLB:SiliconNXG72UTiSiXG71X1 iQ1:SDexcludeXG271UTiSiXG302X1 3.9202e-21
C_1_199 BLB:SiliconNXG72UTiSiXG71X1 iQ1:SDexcludeXG277UTiSiXG301X1 1.5668e-21
C_1_200 BLB:SiliconNXG72UTiSiXG71X1 iQ1:SDexcludeXG278UTiSiXG301X1 1.7133e-21
C_1_201 BLB:SiliconNXG72UTiSiXG71X1 iQ1:SiGeBXG291UTiSiXG302X1 9.7455e-23
C_1_202 BLB:SiliconNXG72UTiSiXG71X1 iQ1:SiGeBXG292UTiSiXG302X1 2.3956e-26
C_1_203 BLB:SiliconNXG72UTiSiXG71X1 iQ1:SiGeBXG331UTiSiXG302X1 2.0410e-26
C_1_204 BLB:SiliconNXG72UTiSiXG71X1 iQ1:SiGeBXG335UTiSiXG302X1 1.6785e-26
C_1_205 BLB:SiliconNXG72UTiSiXG71X1 iQ1:SiliconNXG308UTiSiXG301X1 9.3575e-23
C_1_206 BLB:SiliconNXG72UTiSiXG71X1 iQ1:n1d 3.3729e-21
C_1_207 BLB:SiliconNXG72UTiSiXG71X1 iQ1:n2s 3.3729e-21
C_1_208 BLB:SiliconNXG72UTiSiXG71X1 iQ1:n4g 5.5931e-23
C_1_209 BLB:SiliconNXG72UTiSiXG71X1 iQ1:p1d 4.0176e-21
C_1_210 BLB:SiliconNXG72UTiSiXG71X1 iQ1:p2g 2.4238e-23
C_1_211 BLB:SiliconNXG72UTiSiXG71X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.8491e-19
C_1_212 BLB:SiliconNXG72UTiSiXG71X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 4.6545e-21
C_1_213 BLB:SiliconNXG72UTiSiXG71X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 3.8442e-21
C_1_214 BLB:SiliconNXG72UTiSiXG71X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 3.8613e-21
C_1_215 BLB:SiliconNXG72UTiSiXG71X1 iQ2:SDexcludeXG272UTiSiXG305X1 7.2724e-21
C_1_216 BLB:SiliconNXG72UTiSiXG71X1 iQ2:SDexcludeXG279UTiSiXG306X1 6.1574e-21
C_1_217 BLB:SiliconNXG72UTiSiXG71X1 iQ2:SDexcludeXG280UTiSiXG306X1 6.5942e-21
C_1_218 BLB:SiliconNXG72UTiSiXG71X1 iQ2:SiGeBXG294UTiSiXG305X1 8.1619e-22
C_1_219 BLB:SiliconNXG72UTiSiXG71X1 iQ2:SiGeBXG296UTiSiXG305X1 2.9613e-24
C_1_220 BLB:SiliconNXG72UTiSiXG71X1 iQ2:SiGeBXG336UTiSiXG305X1 2.9558e-24
C_1_221 BLB:SiliconNXG72UTiSiXG71X1 iQ2:SiliconNXG311UTiSiXG306X1 7.2308e-22
C_1_222 BLB:SiliconNXG72UTiSiXG71X1 iQ2:n1g 3.6736e-23
C_1_223 BLB:SiliconNXG72UTiSiXG71X1 iQ2:n3d 1.3415e-20
C_1_224 BLB:SiliconNXG72UTiSiXG71X1 iQ2:n4s 1.3415e-20
C_1_225 BLB:SiliconNXG72UTiSiXG71X1 iQ2:p1g 6.4305e-23
C_1_226 BLB:SiliconNXG72UTiSiXG71X1 iQ2:p2s 8.0827e-21
C_1_227 BLB:n3s WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 5.4389e-18
C_1_228 BLB:n3s WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 8.8401e-20
C_1_229 BLB:n3s WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 4.0059e-20
C_1_230 BLB:n3s WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 7.4879e-23
C_1_231 BLB:n3s WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 1.4896e-22
C_1_232 BLB:n3s WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 2.2180e-23
C_1_233 BLB:n3s WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 5.4453e-22
C_1_234 BLB:n3s WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.7147e-20
C_1_235 BLB:n3s iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 1.8914e-19
C_1_236 BLB:n3s iQ1:LM00Cobalt2XG314USiGeBXG291X1 7.4793e-22
C_1_237 BLB:n3s iQ1:LM00Cobalt2XG314UTiSiXG301X1 8.3049e-23
C_1_238 BLB:n3s iQ1:LM00Cobalt2XG314UTiSiXG302X1 8.1068e-23
C_1_239 BLB:n3s iQ1:SDexcludeXG271UTiSiXG302X1 2.6597e-20
C_1_240 BLB:n3s iQ1:SDexcludeXG277UTiSiXG301X1 1.1173e-20
C_1_241 BLB:n3s iQ1:SDexcludeXG278UTiSiXG301X1 1.2079e-20
C_1_242 BLB:n3s iQ1:SiGeBXG291UTiSiXG302X1 6.6699e-22
C_1_243 BLB:n3s iQ1:SiGeBXG292UTiSiXG302X1 8.9292e-26
C_1_244 BLB:n3s iQ1:SiGeBXG331UTiSiXG302X1 9.4812e-26
C_1_245 BLB:n3s iQ1:SiGeBXG335UTiSiXG302X1 6.7518e-26
C_1_246 BLB:n3s iQ1:SiliconNXG308UTiSiXG301X1 6.6129e-22
C_1_247 BLB:n3s iQ1:n1d 2.3908e-20
C_1_248 BLB:n3s iQ1:n2s 2.3908e-20
C_1_249 BLB:n3s iQ1:p1d 2.7264e-20
C_1_250 BLB:n3s iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 5.9557e-19
C_1_251 BLB:n3s iQ2:LM00Cobalt2XG151USiGeBXG294X1 7.1175e-21
C_1_252 BLB:n3s iQ2:LM00Cobalt2XG151UTiSiXG305X1 4.6984e-21
C_1_253 BLB:n3s iQ2:LM00Cobalt2XG151UTiSiXG306X1 4.7264e-21
C_1_254 BLB:n3s iQ2:SDexcludeXG272UTiSiXG305X1 5.0640e-20
C_1_255 BLB:n3s iQ2:SDexcludeXG279UTiSiXG306X1 9.8874e-20
C_1_256 BLB:n3s iQ2:SDexcludeXG280UTiSiXG306X1 1.0549e-19
C_1_257 BLB:n3s iQ2:SiGeBXG294UTiSiXG305X1 2.4265e-21
C_1_258 BLB:n3s iQ2:SiGeBXG296UTiSiXG305X1 3.6994e-24
C_1_259 BLB:n3s iQ2:SiGeBXG336UTiSiXG305X1 3.6781e-24
C_1_260 BLB:n3s iQ2:SiliconNXG311UTiSiXG306X1 4.2158e-21
C_1_261 BLB:n3s iQ2:n3d 2.0848e-19
C_1_262 BLB:n3s iQ2:n4s 2.0848e-19
C_1_263 BLB:n3s iQ2:p2s 5.3060e-20
R_1_0 BLBD BLBU 1.1569e+01
R_1_1 BLBD BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 1.0178e+03
R_1_2 BLBU BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 3.4199e+01
R_1_3 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 5.8021e+01
R_1_4 BLB:LM00Cobalt2XG70UTiSiXG71X1 BLB:SiliconNXG72UTiSiXG71X1 1.7694e+02
R_1_5 BLB:SiliconNXG72UTiSiXG71X1 BLB:n3s 1.9140e+01

*|NET VDD 6.5679e-05PF
C_2_0 BLBD VDD 7.6123e-19
C_2_1 BLBD VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 8.3883e-19
C_2_2 BLBD VDD:LM00Cobalt2XG548UTiSiXG539X1 7.7930e-20
C_2_3 BLBD VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 7.6838e-19
C_2_4 BLBD VDD:LM00Cobalt2XG57UTiSiXG58X1 7.2342e-21
C_2_5 BLBD VDD:SiGeBXG523UTiSiXG539X1 2.6706e-21
C_2_6 BLBD VDD:SiGeBXG59UTiSiXG58X1 1.0508e-21
C_2_7 BLBD VDD:p1s 1.2842e-21
C_2_8 BLBD VDD:p2d 2.7917e-21
C_2_9 BLBU VDD 7.6123e-19
C_2_10 BLBU VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 8.3883e-19
C_2_11 BLBU VDD:LM00Cobalt2XG548UTiSiXG539X1 7.7930e-20
C_2_12 BLBU VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 7.6838e-19
C_2_13 BLBU VDD:LM00Cobalt2XG57UTiSiXG58X1 7.2342e-21
C_2_14 BLBU VDD:SiGeBXG523UTiSiXG539X1 2.6706e-21
C_2_15 BLBU VDD:SiGeBXG59UTiSiXG58X1 1.0508e-21
C_2_16 BLBU VDD:p1s 1.2842e-21
C_2_17 BLBU VDD:p2d 2.7917e-21
C_2_18 BLD VDD 7.6152e-19
C_2_19 BLD VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 7.6861e-19
C_2_20 BLD VDD:LM00Cobalt2XG548UTiSiXG539X1 7.1711e-21
C_2_21 BLD VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 8.3924e-19
C_2_22 BLD VDD:LM00Cobalt2XG57UTiSiXG58X1 7.8047e-20
C_2_23 BLD VDD:SiGeBXG523UTiSiXG539X1 1.0379e-21
C_2_24 BLD VDD:SiGeBXG59UTiSiXG58X1 2.6734e-21
C_2_25 BLD VDD:p1s 2.8016e-21
C_2_26 BLD VDD:p2d 1.2695e-21
C_2_27 BLU VDD 7.6152e-19
C_2_28 BLU VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 7.6861e-19
C_2_29 BLU VDD:LM00Cobalt2XG548UTiSiXG539X1 7.1711e-21
C_2_30 BLU VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 8.3924e-19
C_2_31 BLU VDD:LM00Cobalt2XG57UTiSiXG58X1 7.8047e-20
C_2_32 BLU VDD:SiGeBXG523UTiSiXG539X1 1.0379e-21
C_2_33 BLU VDD:SiGeBXG59UTiSiXG58X1 2.6734e-21
C_2_34 BLU VDD:p1s 2.8016e-21
C_2_35 BLU VDD:p2d 1.2695e-21
C_2_36 VDD VSS 1.3380e-18
C_2_37 VDD VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 3.8424e-20
C_2_38 VDD VSS:LM00Cobalt2XG20UTiSiXG28X1 3.5379e-20
C_2_39 VDD VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 3.8473e-20
C_2_40 VDD VSS:LM00Cobalt2XG550UTiSiXG541X1 3.5401e-20
C_2_41 VDD VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 4.6252e-21
C_2_42 VDD VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 4.7529e-21
C_2_43 VDD VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 4.1970e-21
C_2_44 VDD VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 4.7272e-21
C_2_45 VDD VSS:SiliconNXG29UTiSiXG28X1 3.1689e-21
C_2_46 VDD VSS:SiliconNXG530UTiSiXG541X1 3.1671e-21
C_2_47 VDD VSS:n1s 3.7100e-21
C_2_48 VDD VSS:n4d 3.7072e-21
C_2_49 VDD WLL 6.4538e-19
C_2_50 VDD WLR 6.4538e-19
C_2_51 VDD BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 8.6212e-19
C_2_52 VDD BLB:LM00Cobalt2XG70UTiSiXG71X1 1.0152e-19
C_2_53 VDD BLB:SiliconNXG72UTiSiXG71X1 8.3342e-21
C_2_54 VDD BLB:n3s 9.7562e-21
C_2_55 VDD BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 8.6580e-19
C_2_56 VDD BL:LM00Cobalt2XG546UTiSiXG535X1 1.0487e-19
C_2_57 VDD BL:SiliconNXG527UTiSiXG535X1 7.9027e-21
C_2_58 VDD BL:n2d 9.3180e-21
C_2_59 VDD WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 2.2069e-20
C_2_60 VDD WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 3.4879e-21
C_2_61 VDD WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 2.1318e-20
C_2_62 VDD WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 2.3969e-21
C_2_63 VDD WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 6.4667e-19
C_2_64 VDD WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 3.1177e-21
C_2_65 VDD WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 6.4626e-19
C_2_66 VDD WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 3.8681e-21
C_2_67 VDD WL:n2g 6.0404e-22
C_2_68 VDD WL:n3g 6.2996e-22
C_2_69 VDD iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 4.9741e-19
C_2_70 VDD iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.1099e-19
C_2_71 VDD iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.1053e-19
C_2_72 VDD iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.1054e-19
C_2_73 VDD iQ1:SDexcludeXG271UTiSiXG302X1 2.7070e-22
C_2_74 VDD iQ1:SDexcludeXG277UTiSiXG301X1 7.2121e-23
C_2_75 VDD iQ1:SDexcludeXG278UTiSiXG301X1 8.9641e-23
C_2_76 VDD iQ1:SiGeBXG291UTiSiXG302X1 4.8348e-22
C_2_77 VDD iQ1:SiGeBXG292UTiSiXG302X1 1.2796e-23
C_2_78 VDD iQ1:SiGeBXG331UTiSiXG302X1 1.2783e-23
C_2_79 VDD iQ1:SiGeBXG335UTiSiXG302X1 1.2783e-23
C_2_80 VDD iQ1:SiliconNXG308UTiSiXG301X1 1.6675e-23
C_2_81 VDD iQ1:n1d 1.6932e-22
C_2_82 VDD iQ1:n2s 1.6932e-22
C_2_83 VDD iQ1:n4g 2.5542e-22
C_2_84 VDD iQ1:p1d 7.2862e-22
C_2_85 VDD iQ1:p2g 8.2133e-22
C_2_86 VDD iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 4.9913e-19
C_2_87 VDD iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.1129e-19
C_2_88 VDD iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.1083e-19
C_2_89 VDD iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.1082e-19
C_2_90 VDD iQ2:SDexcludeXG272UTiSiXG305X1 2.7453e-22
C_2_91 VDD iQ2:SDexcludeXG279UTiSiXG306X1 9.0271e-23
C_2_92 VDD iQ2:SDexcludeXG280UTiSiXG306X1 7.2549e-23
C_2_93 VDD iQ2:SiGeBXG294UTiSiXG305X1 4.8681e-22
C_2_94 VDD iQ2:SiGeBXG296UTiSiXG305X1 1.6138e-23
C_2_95 VDD iQ2:SiGeBXG336UTiSiXG305X1 1.6174e-23
C_2_96 VDD iQ2:SiliconNXG311UTiSiXG306X1 1.7155e-23
C_2_97 VDD iQ2:n1g 2.5573e-22
C_2_98 VDD iQ2:n3d 1.7073e-22
C_2_99 VDD iQ2:n4s 1.7073e-22
C_2_100 VDD iQ2:p1g 8.2383e-22
C_2_101 VDD iQ2:p2s 7.2908e-22
C_2_102 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS 1.3541e-18
C_2_103 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 3.8445e-20
C_2_104 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS:LM00Cobalt2XG20UTiSiXG28X1 3.5403e-20
C_2_105 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 4.2375e-19
C_2_106 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS:LM00Cobalt2XG550UTiSiXG541X1 4.3343e-19
C_2_107 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 4.6253e-21
C_2_108 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 4.7532e-21
C_2_109 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 4.9261e-21
C_2_110 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 7.7987e-21
C_2_111 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS:SiliconNXG29UTiSiXG28X1 3.3518e-21
C_2_112 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS:SiliconNXG530UTiSiXG541X1 9.3111e-20
C_2_113 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS:n1s 5.1326e-21
C_2_114 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VSS:n4d 9.0648e-20
C_2_115 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 WLL 6.4620e-19
C_2_116 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 WLR 6.4620e-19
C_2_117 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 9.3976e-19
C_2_118 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 1.0156e-19
C_2_119 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 BLB:SiliconNXG72UTiSiXG71X1 8.5325e-21
C_2_120 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 BLB:n3s 1.1265e-20
C_2_121 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 9.1787e-19
C_2_122 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 BL:LM00Cobalt2XG546UTiSiXG535X1 1.5066e-19
C_2_123 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 BL:SiliconNXG527UTiSiXG535X1 2.3406e-20
C_2_124 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 BL:n2d 3.1543e-20
C_2_125 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 2.2961e-20
C_2_126 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 3.5134e-21
C_2_127 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 3.3642e-20
C_2_128 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 2.7606e-21
C_2_129 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 6.4755e-19
C_2_130 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 3.3896e-21
C_2_131 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 6.4709e-19
C_2_132 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 3.8907e-21
C_2_133 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 WL:n2g 2.5481e-21
C_2_134 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 WL:n3g 1.1969e-21
C_2_135 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 2.6907e-18
C_2_136 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.3929e-19
C_2_137 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.3871e-19
C_2_138 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.3872e-19
C_2_139 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:SDexcludeXG271UTiSiXG302X1 1.0799e-21
C_2_140 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:SDexcludeXG277UTiSiXG301X1 3.3063e-22
C_2_141 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:SDexcludeXG278UTiSiXG301X1 4.2012e-22
C_2_142 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:SiGeBXG291UTiSiXG302X1 5.9245e-22
C_2_143 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:SiGeBXG292UTiSiXG302X1 1.4053e-23
C_2_144 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:SiGeBXG331UTiSiXG302X1 1.4028e-23
C_2_145 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:SiGeBXG335UTiSiXG302X1 1.4028e-23
C_2_146 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:SiliconNXG308UTiSiXG301X1 5.1977e-23
C_2_147 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:n1d 7.8922e-22
C_2_148 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:n2s 7.8922e-22
C_2_149 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:n4g 3.9624e-21
C_2_150 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:p1d 1.6443e-21
C_2_151 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ1:p2g 1.2735e-19
C_2_152 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 5.2806e-19
C_2_153 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.3531e-19
C_2_154 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.3477e-19
C_2_155 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.3475e-19
C_2_156 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:SDexcludeXG272UTiSiXG305X1 1.0392e-21
C_2_157 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:SDexcludeXG279UTiSiXG306X1 4.3089e-22
C_2_158 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:SDexcludeXG280UTiSiXG306X1 3.6504e-22
C_2_159 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:SiGeBXG294UTiSiXG305X1 5.8263e-22
C_2_160 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:SiGeBXG296UTiSiXG305X1 2.0662e-23
C_2_161 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:SiGeBXG336UTiSiXG305X1 2.0701e-23
C_2_162 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:SiliconNXG311UTiSiXG306X1 3.7184e-23
C_2_163 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:n1g 7.9127e-22
C_2_164 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:n3d 8.2166e-22
C_2_165 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:n4s 8.2166e-22
C_2_166 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:p1g 1.1494e-21
C_2_167 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 iQ2:p2s 1.5805e-21
C_2_168 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS 1.6114e-20
C_2_169 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 2.2518e-23
C_2_170 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS:LM00Cobalt2XG20UTiSiXG28X1 2.4634e-23
C_2_171 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 3.8965e-19
C_2_172 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS:LM00Cobalt2XG550UTiSiXG541X1 4.0301e-19
C_2_173 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 1.6784e-25
C_2_174 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 3.5785e-25
C_2_175 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 7.3498e-22
C_2_176 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 3.1076e-21
C_2_177 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS:SiliconNXG29UTiSiXG28X1 1.9602e-22
C_2_178 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS:SiliconNXG530UTiSiXG541X1 9.5018e-20
C_2_179 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS:n1s 1.5300e-21
C_2_180 VDD:LM00Cobalt2XG548UTiSiXG539X1 VSS:n4d 9.2419e-20
C_2_181 VDD:LM00Cobalt2XG548UTiSiXG539X1 WLL 8.2632e-22
C_2_182 VDD:LM00Cobalt2XG548UTiSiXG539X1 WLR 8.2632e-22
C_2_183 VDD:LM00Cobalt2XG548UTiSiXG539X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 7.7978e-20
C_2_184 VDD:LM00Cobalt2XG548UTiSiXG539X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 4.9398e-23
C_2_185 VDD:LM00Cobalt2XG548UTiSiXG539X1 BLB:SiliconNXG72UTiSiXG71X1 2.1436e-22
C_2_186 VDD:LM00Cobalt2XG548UTiSiXG539X1 BLB:n3s 1.6319e-21
C_2_187 VDD:LM00Cobalt2XG548UTiSiXG539X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 5.3090e-20
C_2_188 VDD:LM00Cobalt2XG548UTiSiXG539X1 BL:LM00Cobalt2XG546UTiSiXG535X1 4.6750e-20
C_2_189 VDD:LM00Cobalt2XG548UTiSiXG539X1 BL:SiliconNXG527UTiSiXG535X1 1.6107e-20
C_2_190 VDD:LM00Cobalt2XG548UTiSiXG539X1 BL:n2d 2.3235e-20
C_2_191 VDD:LM00Cobalt2XG548UTiSiXG539X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 9.6115e-22
C_2_192 VDD:LM00Cobalt2XG548UTiSiXG539X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 2.5694e-23
C_2_193 VDD:LM00Cobalt2XG548UTiSiXG539X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 1.2785e-20
C_2_194 VDD:LM00Cobalt2XG548UTiSiXG539X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 3.7066e-22
C_2_195 VDD:LM00Cobalt2XG548UTiSiXG539X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 8.8865e-22
C_2_196 VDD:LM00Cobalt2XG548UTiSiXG539X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 2.7633e-22
C_2_197 VDD:LM00Cobalt2XG548UTiSiXG539X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 8.2691e-22
C_2_198 VDD:LM00Cobalt2XG548UTiSiXG539X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 2.2699e-23
C_2_199 VDD:LM00Cobalt2XG548UTiSiXG539X1 WL:n2g 2.0555e-21
C_2_200 VDD:LM00Cobalt2XG548UTiSiXG539X1 WL:n3g 6.1371e-22
C_2_201 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 2.2144e-18
C_2_202 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.8433e-20
C_2_203 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.8325e-20
C_2_204 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.8324e-20
C_2_205 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:SDexcludeXG271UTiSiXG302X1 8.6843e-22
C_2_206 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:SDexcludeXG277UTiSiXG301X1 2.7733e-22
C_2_207 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:SDexcludeXG278UTiSiXG301X1 3.5406e-22
C_2_208 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:SiGeBXG291UTiSiXG302X1 1.1154e-22
C_2_209 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:SiGeBXG292UTiSiXG302X1 1.2642e-24
C_2_210 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:SiGeBXG331UTiSiXG302X1 1.2522e-24
C_2_211 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:SiGeBXG335UTiSiXG302X1 1.2522e-24
C_2_212 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:SiliconNXG308UTiSiXG301X1 3.7219e-23
C_2_213 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:n1d 6.6409e-22
C_2_214 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:n2s 6.6409e-22
C_2_215 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:n4g 3.9200e-21
C_2_216 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:p1d 9.7747e-22
C_2_217 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ1:p2g 1.2904e-19
C_2_218 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.9137e-20
C_2_219 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.4030e-20
C_2_220 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.3942e-20
C_2_221 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.3938e-20
C_2_222 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:SDexcludeXG272UTiSiXG305X1 8.2615e-22
C_2_223 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:SDexcludeXG279UTiSiXG306X1 3.6943e-22
C_2_224 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:SDexcludeXG280UTiSiXG306X1 3.1680e-22
C_2_225 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:SiGeBXG294UTiSiXG305X1 9.7254e-23
C_2_226 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:SiGeBXG296UTiSiXG305X1 4.5264e-24
C_2_227 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:SiGeBXG336UTiSiXG305X1 4.5287e-24
C_2_228 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:SiliconNXG311UTiSiXG306X1 2.1604e-23
C_2_229 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:n1g 5.7583e-22
C_2_230 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:n3d 7.0560e-22
C_2_231 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:n4s 7.0560e-22
C_2_232 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:p1g 3.4976e-22
C_2_233 VDD:LM00Cobalt2XG548UTiSiXG539X1 iQ2:p2s 9.1438e-22
C_2_234 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS 1.3538e-18
C_2_235 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 4.2373e-19
C_2_236 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS:LM00Cobalt2XG20UTiSiXG28X1 4.3334e-19
C_2_237 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 3.8493e-20
C_2_238 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS:LM00Cobalt2XG550UTiSiXG541X1 3.5423e-20
C_2_239 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 5.3697e-21
C_2_240 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 7.7977e-21
C_2_241 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 4.1972e-21
C_2_242 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 4.7276e-21
C_2_243 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS:SiliconNXG29UTiSiXG28X1 9.2884e-20
C_2_244 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS:SiliconNXG530UTiSiXG541X1 3.3378e-21
C_2_245 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS:n1s 9.0606e-20
C_2_246 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VSS:n4d 5.1146e-21
C_2_247 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 WLL 6.4620e-19
C_2_248 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 WLR 6.4620e-19
C_2_249 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 9.1192e-19
C_2_250 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 1.4504e-19
C_2_251 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 BLB:SiliconNXG72UTiSiXG71X1 2.4440e-20
C_2_252 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 BLB:n3s 3.2561e-20
C_2_253 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 9.4357e-19
C_2_254 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 BL:LM00Cobalt2XG546UTiSiXG535X1 1.0492e-19
C_2_255 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 BL:SiliconNXG527UTiSiXG535X1 8.1006e-21
C_2_256 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 BL:n2d 1.0828e-20
C_2_257 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 3.4968e-20
C_2_258 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 3.9661e-21
C_2_259 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 2.2211e-20
C_2_260 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 2.4342e-21
C_2_261 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 6.4749e-19
C_2_262 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 3.1524e-21
C_2_263 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 6.4712e-19
C_2_264 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 4.2326e-21
C_2_265 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 WL:n2g 1.1715e-21
C_2_266 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 WL:n3g 2.6035e-21
C_2_267 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 5.2566e-19
C_2_268 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.3500e-19
C_2_269 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.3444e-19
C_2_270 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.3445e-19
C_2_271 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:SDexcludeXG271UTiSiXG302X1 1.0362e-21
C_2_272 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:SDexcludeXG277UTiSiXG301X1 3.6504e-22
C_2_273 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:SDexcludeXG278UTiSiXG301X1 4.3073e-22
C_2_274 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:SiGeBXG291UTiSiXG302X1 5.7868e-22
C_2_275 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:SiGeBXG292UTiSiXG302X1 1.6415e-23
C_2_276 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:SiGeBXG331UTiSiXG302X1 1.6398e-23
C_2_277 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:SiGeBXG335UTiSiXG302X1 1.6398e-23
C_2_278 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:SiliconNXG308UTiSiXG301X1 3.6755e-23
C_2_279 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:n1d 8.2110e-22
C_2_280 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:n2s 8.2110e-22
C_2_281 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:n4g 7.9194e-22
C_2_282 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:p1d 1.5821e-21
C_2_283 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ1:p2g 1.1488e-21
C_2_284 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.6931e-18
C_2_285 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.3970e-19
C_2_286 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.3914e-19
C_2_287 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.3913e-19
C_2_288 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:SDexcludeXG272UTiSiXG305X1 1.0836e-21
C_2_289 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:SDexcludeXG279UTiSiXG306X1 4.2147e-22
C_2_290 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:SDexcludeXG280UTiSiXG306X1 3.3161e-22
C_2_291 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:SiGeBXG294UTiSiXG305X1 5.9738e-22
C_2_292 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:SiGeBXG296UTiSiXG305X1 1.7679e-23
C_2_293 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:SiGeBXG336UTiSiXG305X1 1.7704e-23
C_2_294 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:SiliconNXG311UTiSiXG306X1 5.2786e-23
C_2_295 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:n1g 3.9943e-21
C_2_296 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:n3d 7.9218e-22
C_2_297 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:n4s 7.9218e-22
C_2_298 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:p1g 1.2807e-19
C_2_299 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 iQ2:p2s 1.6457e-21
C_2_300 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS 1.5825e-20
C_2_301 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 3.8955e-19
C_2_302 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS:LM00Cobalt2XG20UTiSiXG28X1 4.0279e-19
C_2_303 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 2.1501e-23
C_2_304 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS:LM00Cobalt2XG550UTiSiXG541X1 2.3201e-23
C_2_305 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 7.5048e-22
C_2_306 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 3.0803e-21
C_2_307 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 2.1504e-25
C_2_308 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 3.9105e-25
C_2_309 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS:SiliconNXG29UTiSiXG28X1 9.4705e-20
C_2_310 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS:SiliconNXG530UTiSiXG541X1 1.8386e-22
C_2_311 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS:n1s 9.2310e-20
C_2_312 VDD:LM00Cobalt2XG57UTiSiXG58X1 VSS:n4d 1.5155e-21
C_2_313 VDD:LM00Cobalt2XG57UTiSiXG58X1 WLL 8.2791e-22
C_2_314 VDD:LM00Cobalt2XG57UTiSiXG58X1 WLR 8.2791e-22
C_2_315 VDD:LM00Cobalt2XG57UTiSiXG58X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 5.0776e-20
C_2_316 VDD:LM00Cobalt2XG57UTiSiXG58X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 4.4434e-20
C_2_317 VDD:LM00Cobalt2XG57UTiSiXG58X1 BLB:SiliconNXG72UTiSiXG71X1 1.6731e-20
C_2_318 VDD:LM00Cobalt2XG57UTiSiXG58X1 BLB:n3s 2.3838e-20
C_2_319 VDD:LM00Cobalt2XG57UTiSiXG58X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 7.8097e-20
C_2_320 VDD:LM00Cobalt2XG57UTiSiXG58X1 BL:LM00Cobalt2XG546UTiSiXG535X1 5.1242e-23
C_2_321 VDD:LM00Cobalt2XG57UTiSiXG58X1 BL:SiliconNXG527UTiSiXG535X1 2.1395e-22
C_2_322 VDD:LM00Cobalt2XG57UTiSiXG58X1 BL:n2d 1.6340e-21
C_2_323 VDD:LM00Cobalt2XG57UTiSiXG58X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 1.3377e-20
C_2_324 VDD:LM00Cobalt2XG57UTiSiXG58X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 4.8717e-22
C_2_325 VDD:LM00Cobalt2XG57UTiSiXG58X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 9.6206e-22
C_2_326 VDD:LM00Cobalt2XG57UTiSiXG58X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 3.7507e-23
C_2_327 VDD:LM00Cobalt2XG57UTiSiXG58X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 8.2857e-22
C_2_328 VDD:LM00Cobalt2XG57UTiSiXG58X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 3.4838e-23
C_2_329 VDD:LM00Cobalt2XG57UTiSiXG58X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 8.5855e-22
C_2_330 VDD:LM00Cobalt2XG57UTiSiXG58X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 3.7058e-22
C_2_331 VDD:LM00Cobalt2XG57UTiSiXG58X1 WL:n2g 6.1440e-22
C_2_332 VDD:LM00Cobalt2XG57UTiSiXG58X1 WL:n3g 2.0865e-21
C_2_333 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 2.8455e-20
C_2_334 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.4011e-20
C_2_335 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.3919e-20
C_2_336 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.3922e-20
C_2_337 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:SDexcludeXG271UTiSiXG302X1 8.2736e-22
C_2_338 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:SDexcludeXG277UTiSiXG301X1 3.1731e-22
C_2_339 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:SDexcludeXG278UTiSiXG301X1 3.6999e-22
C_2_340 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:SiGeBXG291UTiSiXG302X1 9.6635e-23
C_2_341 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:SiGeBXG292UTiSiXG302X1 3.6205e-24
C_2_342 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:SiGeBXG331UTiSiXG302X1 3.6173e-24
C_2_343 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:SiGeBXG335UTiSiXG302X1 3.6172e-24
C_2_344 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:SiliconNXG308UTiSiXG301X1 2.1667e-23
C_2_345 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:n1d 7.0663e-22
C_2_346 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:n2s 7.0663e-22
C_2_347 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:n4g 5.7703e-22
C_2_348 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:p1d 9.1676e-22
C_2_349 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ1:p2g 3.5193e-22
C_2_350 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.2151e-18
C_2_351 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.8562e-20
C_2_352 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.8452e-20
C_2_353 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.8452e-20
C_2_354 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:SDexcludeXG272UTiSiXG305X1 8.6852e-22
C_2_355 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:SDexcludeXG279UTiSiXG306X1 3.5493e-22
C_2_356 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:SDexcludeXG280UTiSiXG306X1 2.7800e-22
C_2_357 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:SiGeBXG294UTiSiXG305X1 1.1320e-22
C_2_358 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:SiGeBXG296UTiSiXG305X1 1.5485e-24
C_2_359 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:SiGeBXG336UTiSiXG305X1 1.5371e-24
C_2_360 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:SiliconNXG311UTiSiXG306X1 3.7562e-23
C_2_361 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:n1g 3.9523e-21
C_2_362 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:n3d 6.6593e-22
C_2_363 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:n4s 6.6593e-22
C_2_364 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:p1g 1.2980e-19
C_2_365 VDD:LM00Cobalt2XG57UTiSiXG58X1 iQ2:p2s 9.7865e-22
C_2_366 VDD:SiGeBXG523UTiSiXG539X1 VSS 8.7587e-22
C_2_367 VDD:SiGeBXG523UTiSiXG539X1 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 1.0137e-22
C_2_368 VDD:SiGeBXG523UTiSiXG539X1 VSS:LM00Cobalt2XG20UTiSiXG28X1 1.1066e-22
C_2_369 VDD:SiGeBXG523UTiSiXG539X1 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 4.5139e-20
C_2_370 VDD:SiGeBXG523UTiSiXG539X1 VSS:LM00Cobalt2XG550UTiSiXG541X1 5.4767e-20
C_2_371 VDD:SiGeBXG523UTiSiXG539X1 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 1.1227e-25
C_2_372 VDD:SiGeBXG523UTiSiXG539X1 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 1.5607e-24
C_2_373 VDD:SiGeBXG523UTiSiXG539X1 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 5.1743e-23
C_2_374 VDD:SiGeBXG523UTiSiXG539X1 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 3.6080e-22
C_2_375 VDD:SiGeBXG523UTiSiXG539X1 VSS:SiliconNXG29UTiSiXG28X1 9.5218e-22
C_2_376 VDD:SiGeBXG523UTiSiXG539X1 VSS:SiliconNXG530UTiSiXG541X1 1.5206e-19
C_2_377 VDD:SiGeBXG523UTiSiXG539X1 VSS:n1s 7.7678e-21
C_2_378 VDD:SiGeBXG523UTiSiXG539X1 VSS:n4d 2.1566e-19
C_2_379 VDD:SiGeBXG523UTiSiXG539X1 WLL 4.3262e-23
C_2_380 VDD:SiGeBXG523UTiSiXG539X1 WLR 4.3262e-23
C_2_381 VDD:SiGeBXG523UTiSiXG539X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 2.8004e-21
C_2_382 VDD:SiGeBXG523UTiSiXG539X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 1.3866e-22
C_2_383 VDD:SiGeBXG523UTiSiXG539X1 BLB:SiliconNXG72UTiSiXG71X1 1.2230e-21
C_2_384 VDD:SiGeBXG523UTiSiXG539X1 BLB:n3s 9.3965e-21
C_2_385 VDD:SiGeBXG523UTiSiXG539X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 1.6489e-20
C_2_386 VDD:SiGeBXG523UTiSiXG539X1 BL:LM00Cobalt2XG546UTiSiXG535X1 1.5956e-20
C_2_387 VDD:SiGeBXG523UTiSiXG539X1 BL:SiliconNXG527UTiSiXG535X1 1.6833e-20
C_2_388 VDD:SiGeBXG523UTiSiXG539X1 BL:n2d 3.7321e-20
C_2_389 VDD:SiGeBXG523UTiSiXG539X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 5.2858e-21
C_2_390 VDD:SiGeBXG523UTiSiXG539X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 9.8709e-24
C_2_391 VDD:SiGeBXG523UTiSiXG539X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 1.6788e-20
C_2_392 VDD:SiGeBXG523UTiSiXG539X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 1.2658e-22
C_2_393 VDD:SiGeBXG523UTiSiXG539X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 5.5130e-23
C_2_394 VDD:SiGeBXG523UTiSiXG539X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 6.8913e-23
C_2_395 VDD:SiGeBXG523UTiSiXG539X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 4.3353e-23
C_2_396 VDD:SiGeBXG523UTiSiXG539X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 3.8951e-24
C_2_397 VDD:SiGeBXG523UTiSiXG539X1 WL:n2g 1.1143e-22
C_2_398 VDD:SiGeBXG523UTiSiXG539X1 WL:n3g 4.6753e-23
C_2_399 VDD:SiGeBXG523UTiSiXG539X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 1.6545e-18
C_2_400 VDD:SiGeBXG523UTiSiXG539X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.8647e-21
C_2_401 VDD:SiGeBXG523UTiSiXG539X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 1.7318e-21
C_2_402 VDD:SiGeBXG523UTiSiXG539X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 1.7308e-21
C_2_403 VDD:SiGeBXG523UTiSiXG539X1 iQ1:SDexcludeXG271UTiSiXG302X1 4.2493e-21
C_2_404 VDD:SiGeBXG523UTiSiXG539X1 iQ1:SDexcludeXG277UTiSiXG301X1 1.2899e-21
C_2_405 VDD:SiGeBXG523UTiSiXG539X1 iQ1:SDexcludeXG278UTiSiXG301X1 1.5793e-21
C_2_406 VDD:SiGeBXG523UTiSiXG539X1 iQ1:SiGeBXG291UTiSiXG302X1 1.3416e-22
C_2_407 VDD:SiGeBXG523UTiSiXG539X1 iQ1:SiGeBXG292UTiSiXG302X1 1.4801e-25
C_2_408 VDD:SiGeBXG523UTiSiXG539X1 iQ1:SiGeBXG331UTiSiXG302X1 1.4001e-25
C_2_409 VDD:SiGeBXG523UTiSiXG539X1 iQ1:SiGeBXG335UTiSiXG302X1 1.3974e-25
C_2_410 VDD:SiGeBXG523UTiSiXG539X1 iQ1:SiliconNXG308UTiSiXG301X1 1.0385e-22
C_2_411 VDD:SiGeBXG523UTiSiXG539X1 iQ1:n1d 2.9698e-21
C_2_412 VDD:SiGeBXG523UTiSiXG539X1 iQ1:n2s 2.9698e-21
C_2_413 VDD:SiGeBXG523UTiSiXG539X1 iQ1:n4g 2.1298e-22
C_2_414 VDD:SiGeBXG523UTiSiXG539X1 iQ1:p1d 4.3832e-21
C_2_415 VDD:SiGeBXG523UTiSiXG539X1 iQ1:p2g 2.5103e-21
C_2_416 VDD:SiGeBXG523UTiSiXG539X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.2069e-20
C_2_417 VDD:SiGeBXG523UTiSiXG539X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.0055e-22
C_2_418 VDD:SiGeBXG523UTiSiXG539X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 8.2853e-23
C_2_419 VDD:SiGeBXG523UTiSiXG539X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 8.3155e-23
C_2_420 VDD:SiGeBXG523UTiSiXG539X1 iQ2:SDexcludeXG272UTiSiXG305X1 5.3560e-21
C_2_421 VDD:SiGeBXG523UTiSiXG539X1 iQ2:SDexcludeXG279UTiSiXG306X1 2.3103e-21
C_2_422 VDD:SiGeBXG523UTiSiXG539X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.8255e-21
C_2_423 VDD:SiGeBXG523UTiSiXG539X1 iQ2:SiGeBXG294UTiSiXG305X1 1.1775e-22
C_2_424 VDD:SiGeBXG523UTiSiXG539X1 iQ2:SiGeBXG296UTiSiXG305X1 3.2393e-26
C_2_425 VDD:SiGeBXG523UTiSiXG539X1 iQ2:SiGeBXG336UTiSiXG305X1 3.0937e-26
C_2_426 VDD:SiGeBXG523UTiSiXG539X1 iQ2:SiliconNXG311UTiSiXG306X1 1.1944e-22
C_2_427 VDD:SiGeBXG523UTiSiXG539X1 iQ2:n1g 4.0292e-23
C_2_428 VDD:SiGeBXG523UTiSiXG539X1 iQ2:n3d 4.2542e-21
C_2_429 VDD:SiGeBXG523UTiSiXG539X1 iQ2:n4s 4.2542e-21
C_2_430 VDD:SiGeBXG523UTiSiXG539X1 iQ2:p1g 2.4217e-23
C_2_431 VDD:SiGeBXG523UTiSiXG539X1 iQ2:p2s 5.4737e-21
C_2_432 VDD:SiGeBXG59UTiSiXG58X1 VSS 8.5999e-22
C_2_433 VDD:SiGeBXG59UTiSiXG58X1 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 4.4984e-20
C_2_434 VDD:SiGeBXG59UTiSiXG58X1 VSS:LM00Cobalt2XG20UTiSiXG28X1 5.4488e-20
C_2_435 VDD:SiGeBXG59UTiSiXG58X1 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 1.0153e-22
C_2_436 VDD:SiGeBXG59UTiSiXG58X1 VSS:LM00Cobalt2XG550UTiSiXG541X1 1.1082e-22
C_2_437 VDD:SiGeBXG59UTiSiXG58X1 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 5.2699e-23
C_2_438 VDD:SiGeBXG59UTiSiXG58X1 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 3.5952e-22
C_2_439 VDD:SiGeBXG59UTiSiXG58X1 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 1.4083e-25
C_2_440 VDD:SiGeBXG59UTiSiXG58X1 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 1.5969e-24
C_2_441 VDD:SiGeBXG59UTiSiXG58X1 VSS:SiliconNXG29UTiSiXG28X1 1.5099e-19
C_2_442 VDD:SiGeBXG59UTiSiXG58X1 VSS:SiliconNXG530UTiSiXG541X1 9.5364e-22
C_2_443 VDD:SiGeBXG59UTiSiXG58X1 VSS:n1s 2.1496e-19
C_2_444 VDD:SiGeBXG59UTiSiXG58X1 VSS:n4d 7.7755e-21
C_2_445 VDD:SiGeBXG59UTiSiXG58X1 WLL 4.3394e-23
C_2_446 VDD:SiGeBXG59UTiSiXG58X1 WLR 4.3394e-23
C_2_447 VDD:SiGeBXG59UTiSiXG58X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 1.5480e-20
C_2_448 VDD:SiGeBXG59UTiSiXG58X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 1.4968e-20
C_2_449 VDD:SiGeBXG59UTiSiXG58X1 BLB:SiliconNXG72UTiSiXG71X1 1.7170e-20
C_2_450 VDD:SiGeBXG59UTiSiXG58X1 BLB:n3s 3.7649e-20
C_2_451 VDD:SiGeBXG59UTiSiXG58X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 2.8105e-21
C_2_452 VDD:SiGeBXG59UTiSiXG58X1 BL:LM00Cobalt2XG546UTiSiXG535X1 1.4570e-22
C_2_453 VDD:SiGeBXG59UTiSiXG58X1 BL:SiliconNXG527UTiSiXG535X1 1.2206e-21
C_2_454 VDD:SiGeBXG59UTiSiXG58X1 BL:n2d 9.4014e-21
C_2_455 VDD:SiGeBXG59UTiSiXG58X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 1.7017e-20
C_2_456 VDD:SiGeBXG59UTiSiXG58X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.5471e-22
C_2_457 VDD:SiGeBXG59UTiSiXG58X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 5.2897e-21
C_2_458 VDD:SiGeBXG59UTiSiXG58X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 9.5612e-24
C_2_459 VDD:SiGeBXG59UTiSiXG58X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 4.3689e-23
C_2_460 VDD:SiGeBXG59UTiSiXG58X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 3.6013e-24
C_2_461 VDD:SiGeBXG59UTiSiXG58X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 4.8566e-23
C_2_462 VDD:SiGeBXG59UTiSiXG58X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 9.3497e-23
C_2_463 VDD:SiGeBXG59UTiSiXG58X1 WL:n2g 4.6912e-23
C_2_464 VDD:SiGeBXG59UTiSiXG58X1 WL:n3g 1.1301e-22
C_2_465 VDD:SiGeBXG59UTiSiXG58X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 1.2069e-20
C_2_466 VDD:SiGeBXG59UTiSiXG58X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.9963e-22
C_2_467 VDD:SiGeBXG59UTiSiXG58X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 8.2714e-23
C_2_468 VDD:SiGeBXG59UTiSiXG58X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 8.2250e-23
C_2_469 VDD:SiGeBXG59UTiSiXG58X1 iQ1:SDexcludeXG271UTiSiXG302X1 5.3686e-21
C_2_470 VDD:SiGeBXG59UTiSiXG58X1 iQ1:SDexcludeXG277UTiSiXG301X1 1.8264e-21
C_2_471 VDD:SiGeBXG59UTiSiXG58X1 iQ1:SDexcludeXG278UTiSiXG301X1 2.3112e-21
C_2_472 VDD:SiGeBXG59UTiSiXG58X1 iQ1:SiGeBXG291UTiSiXG302X1 1.1743e-22
C_2_473 VDD:SiGeBXG59UTiSiXG58X1 iQ1:SiGeBXG292UTiSiXG302X1 2.9404e-26
C_2_474 VDD:SiGeBXG59UTiSiXG58X1 iQ1:SiGeBXG331UTiSiXG302X1 2.7063e-26
C_2_475 VDD:SiGeBXG59UTiSiXG58X1 iQ1:SiGeBXG335UTiSiXG302X1 2.6521e-26
C_2_476 VDD:SiGeBXG59UTiSiXG58X1 iQ1:SiliconNXG308UTiSiXG301X1 1.2038e-22
C_2_477 VDD:SiGeBXG59UTiSiXG58X1 iQ1:n1d 4.2565e-21
C_2_478 VDD:SiGeBXG59UTiSiXG58X1 iQ1:n2s 4.2565e-21
C_2_479 VDD:SiGeBXG59UTiSiXG58X1 iQ1:n4g 4.0515e-23
C_2_480 VDD:SiGeBXG59UTiSiXG58X1 iQ1:p1d 5.4860e-21
C_2_481 VDD:SiGeBXG59UTiSiXG58X1 iQ1:p2g 2.4440e-23
C_2_482 VDD:SiGeBXG59UTiSiXG58X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.6505e-18
C_2_483 VDD:SiGeBXG59UTiSiXG58X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 1.9001e-21
C_2_484 VDD:SiGeBXG59UTiSiXG58X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 1.7651e-21
C_2_485 VDD:SiGeBXG59UTiSiXG58X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 1.7659e-21
C_2_486 VDD:SiGeBXG59UTiSiXG58X1 iQ2:SDexcludeXG272UTiSiXG305X1 4.2463e-21
C_2_487 VDD:SiGeBXG59UTiSiXG58X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.5814e-21
C_2_488 VDD:SiGeBXG59UTiSiXG58X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.2914e-21
C_2_489 VDD:SiGeBXG59UTiSiXG58X1 iQ2:SiGeBXG294UTiSiXG305X1 1.3532e-22
C_2_490 VDD:SiGeBXG59UTiSiXG58X1 iQ2:SiGeBXG296UTiSiXG305X1 1.6190e-25
C_2_491 VDD:SiGeBXG59UTiSiXG58X1 iQ2:SiGeBXG336UTiSiXG305X1 1.5739e-25
C_2_492 VDD:SiGeBXG59UTiSiXG58X1 iQ2:SiliconNXG311UTiSiXG306X1 1.0332e-22
C_2_493 VDD:SiGeBXG59UTiSiXG58X1 iQ2:n1g 2.1372e-22
C_2_494 VDD:SiGeBXG59UTiSiXG58X1 iQ2:n3d 2.9731e-21
C_2_495 VDD:SiGeBXG59UTiSiXG58X1 iQ2:n4s 2.9731e-21
C_2_496 VDD:SiGeBXG59UTiSiXG58X1 iQ2:p1g 2.5500e-21
C_2_497 VDD:SiGeBXG59UTiSiXG58X1 iQ2:p2s 4.3814e-21
C_2_498 VDD:p1s VSS 9.2795e-22
C_2_499 VDD:p1s VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 4.8875e-20
C_2_500 VDD:p1s VSS:LM00Cobalt2XG20UTiSiXG28X1 5.8997e-20
C_2_501 VDD:p1s VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 6.9056e-22
C_2_502 VDD:p1s VSS:LM00Cobalt2XG550UTiSiXG541X1 7.5439e-22
C_2_503 VDD:p1s VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 5.7329e-23
C_2_504 VDD:p1s VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 4.2108e-22
C_2_505 VDD:p1s VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 8.4647e-25
C_2_506 VDD:p1s VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 1.0785e-23
C_2_507 VDD:p1s VSS:SiliconNXG29UTiSiXG28X1 2.1521e-19
C_2_508 VDD:p1s VSS:SiliconNXG530UTiSiXG541X1 6.4700e-21
C_2_509 VDD:p1s VSS:n1s 4.8193e-19
C_2_510 VDD:p1s VSS:n4d 5.2248e-20
C_2_511 VDD:p1s WLL 4.6447e-23
C_2_512 VDD:p1s WLR 4.6447e-23
C_2_513 VDD:p1s BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 2.0756e-20
C_2_514 VDD:p1s BLB:LM00Cobalt2XG70UTiSiXG71X1 2.0293e-20
C_2_515 VDD:p1s BLB:SiliconNXG72UTiSiXG71X1 3.6129e-20
C_2_516 VDD:p1s BLB:n3s 1.2225e-19
C_2_517 VDD:p1s BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 3.8056e-21
C_2_518 VDD:p1s BL:LM00Cobalt2XG546UTiSiXG535X1 1.0669e-21
C_2_519 VDD:p1s BL:SiliconNXG527UTiSiXG535X1 8.8489e-21
C_2_520 VDD:p1s BL:n2d 6.8074e-20
C_2_521 VDD:p1s WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 5.6675e-20
C_2_522 VDD:p1s WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 2.6836e-22
C_2_523 VDD:p1s WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 3.9797e-20
C_2_524 VDD:p1s WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 6.1431e-23
C_2_525 VDD:p1s WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 4.8323e-23
C_2_526 VDD:p1s WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.8740e-23
C_2_527 VDD:p1s WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 5.3228e-23
C_2_528 VDD:p1s WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.4279e-22
C_2_529 VDD:p1s iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 9.0238e-20
C_2_530 VDD:p1s iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.5142e-21
C_2_531 VDD:p1s iQ1:LM00Cobalt2XG314UTiSiXG301X1 1.6721e-22
C_2_532 VDD:p1s iQ1:LM00Cobalt2XG314UTiSiXG302X1 1.6471e-22
C_2_533 VDD:p1s iQ1:SDexcludeXG271UTiSiXG302X1 1.4135e-19
C_2_534 VDD:p1s iQ1:SDexcludeXG277UTiSiXG301X1 1.2422e-20
C_2_535 VDD:p1s iQ1:SDexcludeXG278UTiSiXG301X1 1.7814e-20
C_2_536 VDD:p1s iQ1:SiGeBXG291UTiSiXG302X1 1.3499e-21
C_2_537 VDD:p1s iQ1:SiGeBXG292UTiSiXG302X1 2.0478e-25
C_2_538 VDD:p1s iQ1:SiGeBXG331UTiSiXG302X1 1.8912e-25
C_2_539 VDD:p1s iQ1:SiGeBXG335UTiSiXG302X1 1.8360e-25
C_2_540 VDD:p1s iQ1:SiliconNXG308UTiSiXG301X1 9.4875e-22
C_2_541 VDD:p1s iQ1:n1d 3.1176e-20
C_2_542 VDD:p1s iQ1:n2s 3.1176e-20
C_2_543 VDD:p1s iQ1:p1d 1.4270e-19
C_2_544 VDD:p1s iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 3.6520e-18
C_2_545 VDD:p1s iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.9100e-21
C_2_546 VDD:p1s iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.0733e-21
C_2_547 VDD:p1s iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.0753e-21
C_2_548 VDD:p1s iQ2:SDexcludeXG272UTiSiXG305X1 2.9307e-20
C_2_549 VDD:p1s iQ2:SDexcludeXG279UTiSiXG306X1 9.6559e-21
C_2_550 VDD:p1s iQ2:SDexcludeXG280UTiSiXG306X1 8.1263e-21
C_2_551 VDD:p1s iQ2:SiGeBXG294UTiSiXG305X1 8.3717e-22
C_2_552 VDD:p1s iQ2:SiGeBXG296UTiSiXG305X1 2.7447e-25
C_2_553 VDD:p1s iQ2:SiGeBXG336UTiSiXG305X1 2.5900e-25
C_2_554 VDD:p1s iQ2:SiliconNXG311UTiSiXG306X1 5.5699e-22
C_2_555 VDD:p1s iQ2:n3d 1.8333e-20
C_2_556 VDD:p1s iQ2:n4s 1.8333e-20
C_2_557 VDD:p1s iQ2:p2s 3.0144e-20
C_2_558 VDD:p2d VSS 9.4484e-22
C_2_559 VDD:p2d VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 6.9024e-22
C_2_560 VDD:p2d VSS:LM00Cobalt2XG20UTiSiXG28X1 7.5409e-22
C_2_561 VDD:p2d VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 4.8879e-20
C_2_562 VDD:p2d VSS:LM00Cobalt2XG550UTiSiXG541X1 5.9106e-20
C_2_563 VDD:p2d VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 7.9871e-25
C_2_564 VDD:p2d VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 1.0691e-23
C_2_565 VDD:p2d VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 5.5991e-23
C_2_566 VDD:p2d VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 4.2170e-22
C_2_567 VDD:p2d VSS:SiliconNXG29UTiSiXG28X1 6.4666e-21
C_2_568 VDD:p2d VSS:SiliconNXG530UTiSiXG541X1 2.1623e-19
C_2_569 VDD:p2d VSS:n1s 5.2251e-20
C_2_570 VDD:p2d VSS:n4d 4.8246e-19
C_2_571 VDD:p2d WLL 4.6427e-23
C_2_572 VDD:p2d WLR 4.6427e-23
C_2_573 VDD:p2d BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 3.7429e-21
C_2_574 VDD:p2d BLB:LM00Cobalt2XG70UTiSiXG71X1 1.0161e-21
C_2_575 VDD:p2d BLB:SiliconNXG72UTiSiXG71X1 8.8761e-21
C_2_576 VDD:p2d BLB:n3s 6.8106e-20
C_2_577 VDD:p2d BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 2.2141e-20
C_2_578 VDD:p2d BL:LM00Cobalt2XG546UTiSiXG535X1 2.1646e-20
C_2_579 VDD:p2d BL:SiliconNXG527UTiSiXG535X1 3.5660e-20
C_2_580 VDD:p2d BL:n2d 1.2182e-19
C_2_581 VDD:p2d WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 3.9806e-20
C_2_582 VDD:p2d WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 6.6679e-23
C_2_583 VDD:p2d WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 5.6400e-20
C_2_584 VDD:p2d WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 2.2704e-22
C_2_585 VDD:p2d WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 6.2957e-23
C_2_586 VDD:p2d WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.0547e-22
C_2_587 VDD:p2d WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 4.6921e-23
C_2_588 VDD:p2d WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 2.4043e-23
C_2_589 VDD:p2d iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 3.6529e-18
C_2_590 VDD:p2d iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.8531e-21
C_2_591 VDD:p2d iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.0208e-21
C_2_592 VDD:p2d iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.0184e-21
C_2_593 VDD:p2d iQ1:SDexcludeXG271UTiSiXG302X1 2.9369e-20
C_2_594 VDD:p2d iQ1:SDexcludeXG277UTiSiXG301X1 8.1253e-21
C_2_595 VDD:p2d iQ1:SDexcludeXG278UTiSiXG301X1 9.6530e-21
C_2_596 VDD:p2d iQ1:SiGeBXG291UTiSiXG302X1 8.3518e-22
C_2_597 VDD:p2d iQ1:SiGeBXG292UTiSiXG302X1 2.6303e-25
C_2_598 VDD:p2d iQ1:SiGeBXG331UTiSiXG302X1 2.3666e-25
C_2_599 VDD:p2d iQ1:SiGeBXG335UTiSiXG302X1 2.3263e-25
C_2_600 VDD:p2d iQ1:SiliconNXG308UTiSiXG301X1 5.6154e-22
C_2_601 VDD:p2d iQ1:n1d 1.8332e-20
C_2_602 VDD:p2d iQ1:n2s 1.8332e-20
C_2_603 VDD:p2d iQ1:p1d 3.0204e-20
C_2_604 VDD:p2d iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 9.0369e-20
C_2_605 VDD:p2d iQ2:LM00Cobalt2XG151USiGeBXG294X1 1.5248e-21
C_2_606 VDD:p2d iQ2:LM00Cobalt2XG151UTiSiXG305X1 1.6978e-22
C_2_607 VDD:p2d iQ2:LM00Cobalt2XG151UTiSiXG306X1 1.7141e-22
C_2_608 VDD:p2d iQ2:SDexcludeXG272UTiSiXG305X1 1.4163e-19
C_2_609 VDD:p2d iQ2:SDexcludeXG279UTiSiXG306X1 1.7824e-20
C_2_610 VDD:p2d iQ2:SDexcludeXG280UTiSiXG306X1 1.2427e-20
C_2_611 VDD:p2d iQ2:SiGeBXG294UTiSiXG305X1 1.3554e-21
C_2_612 VDD:p2d iQ2:SiGeBXG296UTiSiXG305X1 2.1523e-25
C_2_613 VDD:p2d iQ2:SiGeBXG336UTiSiXG305X1 1.9145e-25
C_2_614 VDD:p2d iQ2:SiliconNXG311UTiSiXG306X1 9.3975e-22
C_2_615 VDD:p2d iQ2:n3d 3.1185e-20
C_2_616 VDD:p2d iQ2:n4s 3.1185e-20
C_2_617 VDD:p2d iQ2:p2s 1.4298e-19
R_2_0 VDD VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 5.2100e+01
R_2_1 VDD VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 5.0610e+01
R_2_2 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VDD:LM00Cobalt2XG548UTiSiXG539X1 8.3500e+01
R_2_3 VDD:LM00Cobalt2XG548ULM40Cobalt5XG63X1 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 1.1719e+03
R_2_4 VDD:LM00Cobalt2XG548UTiSiXG539X1 VDD:SiGeBXG523UTiSiXG539X1 2.2851e+02
R_2_5 VDD:LM00Cobalt2XG57ULM40Cobalt5XG63X1 VDD:LM00Cobalt2XG57UTiSiXG58X1 8.3500e+01
R_2_6 VDD:LM00Cobalt2XG57UTiSiXG58X1 VDD:SiGeBXG59UTiSiXG58X1 2.2674e+02
R_2_7 VDD:SiGeBXG523UTiSiXG539X1 VDD:p2d 3.7231e+01
R_2_8 VDD:SiGeBXG59UTiSiXG58X1 VDD:p1s 3.5663e+01

*|NET VSS 8.5623e-05PF
C_3_0 BLBD VSS 7.9832e-19
C_3_1 BLBD VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 2.6042e-22
C_3_2 BLBD VSS:LM00Cobalt2XG20UTiSiXG28X1 2.5435e-22
C_3_3 BLBD VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 9.1822e-19
C_3_4 BLBD VSS:LM00Cobalt2XG550UTiSiXG541X1 3.5883e-19
C_3_5 BLBD VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 2.7603e-23
C_3_6 BLBD VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 2.0660e-23
C_3_7 BLBD VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 1.4710e-19
C_3_8 BLBD VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 6.3783e-19
C_3_9 BLBD VSS:SiliconNXG29UTiSiXG28X1 1.1612e-22
C_3_10 BLBD VSS:SiliconNXG530UTiSiXG541X1 1.0718e-20
C_3_11 BLBD VSS:n1s 2.3895e-22
C_3_12 BLBD VSS:n4d 1.0743e-20
C_3_13 BLBU VSS 7.9832e-19
C_3_14 BLBU VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 2.6042e-22
C_3_15 BLBU VSS:LM00Cobalt2XG20UTiSiXG28X1 2.5435e-22
C_3_16 BLBU VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 9.1822e-19
C_3_17 BLBU VSS:LM00Cobalt2XG550UTiSiXG541X1 3.5883e-19
C_3_18 BLBU VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 2.7603e-23
C_3_19 BLBU VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 2.0660e-23
C_3_20 BLBU VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 1.4710e-19
C_3_21 BLBU VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 6.3783e-19
C_3_22 BLBU VSS:SiliconNXG29UTiSiXG28X1 1.1612e-22
C_3_23 BLBU VSS:SiliconNXG530UTiSiXG541X1 1.0718e-20
C_3_24 BLBU VSS:n1s 2.3895e-22
C_3_25 BLBU VSS:n4d 1.0743e-20
C_3_26 BLD VSS 8.0988e-19
C_3_27 BLD VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 8.5532e-19
C_3_28 BLD VSS:LM00Cobalt2XG20UTiSiXG28X1 3.5899e-19
C_3_29 BLD VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 2.5868e-22
C_3_30 BLD VSS:LM00Cobalt2XG550UTiSiXG541X1 2.5271e-22
C_3_31 BLD VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 1.5139e-19
C_3_32 BLD VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 5.7559e-19
C_3_33 BLD VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 2.4534e-23
C_3_34 BLD VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 2.0206e-23
C_3_35 BLD VSS:SiliconNXG29UTiSiXG28X1 1.0733e-20
C_3_36 BLD VSS:SiliconNXG530UTiSiXG541X1 1.1544e-22
C_3_37 BLD VSS:n1s 1.0756e-20
C_3_38 BLD VSS:n4d 2.3853e-22
C_3_39 BLU VSS 8.0988e-19
C_3_40 BLU VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 8.5532e-19
C_3_41 BLU VSS:LM00Cobalt2XG20UTiSiXG28X1 3.5899e-19
C_3_42 BLU VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 2.5868e-22
C_3_43 BLU VSS:LM00Cobalt2XG550UTiSiXG541X1 2.5271e-22
C_3_44 BLU VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 1.5139e-19
C_3_45 BLU VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 5.7559e-19
C_3_46 BLU VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 2.4534e-23
C_3_47 BLU VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 2.0206e-23
C_3_48 BLU VSS:SiliconNXG29UTiSiXG28X1 1.0733e-20
C_3_49 BLU VSS:SiliconNXG530UTiSiXG541X1 1.1544e-22
C_3_50 BLU VSS:n1s 1.0756e-20
C_3_51 BLU VSS:n4d 2.3853e-22
C_3_52 VSS WLL 4.0470e-18
C_3_53 VSS WLR 4.0470e-18
C_3_54 VSS BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 8.2600e-19
C_3_55 VSS BLB:LM00Cobalt2XG70UTiSiXG71X1 2.7862e-20
C_3_56 VSS BLB:SiliconNXG72UTiSiXG71X1 3.4842e-21
C_3_57 VSS BLB:n3s 3.7386e-21
C_3_58 VSS BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 8.4125e-19
C_3_59 VSS BL:LM00Cobalt2XG546UTiSiXG535X1 3.1563e-20
C_3_60 VSS BL:SiliconNXG527UTiSiXG535X1 4.0337e-21
C_3_61 VSS BL:n2d 4.3214e-21
C_3_62 VSS WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 5.3021e-21
C_3_63 VSS WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.6245e-19
C_3_64 VSS WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 7.4945e-21
C_3_65 VSS WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 8.1842e-20
C_3_66 VSS WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 4.3592e-18
C_3_67 VSS WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 3.8859e-19
C_3_68 VSS WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 4.2879e-18
C_3_69 VSS WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 3.9981e-19
C_3_70 VSS WL:n2g 1.3703e-22
C_3_71 VSS WL:n3g 1.2148e-22
C_3_72 VSS iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 5.6681e-21
C_3_73 VSS iQ1:LM00Cobalt2XG314USiGeBXG291X1 7.3303e-22
C_3_74 VSS iQ1:LM00Cobalt2XG314UTiSiXG301X1 7.3146e-22
C_3_75 VSS iQ1:LM00Cobalt2XG314UTiSiXG302X1 7.3139e-22
C_3_76 VSS iQ1:SDexcludeXG271UTiSiXG302X1 2.2411e-23
C_3_77 VSS iQ1:SDexcludeXG277UTiSiXG301X1 1.1678e-23
C_3_78 VSS iQ1:SDexcludeXG278UTiSiXG301X1 1.2069e-23
C_3_79 VSS iQ1:SiGeBXG291UTiSiXG302X1 1.6699e-24
C_3_80 VSS iQ1:SiGeBXG292UTiSiXG302X1 1.5833e-26
C_3_81 VSS iQ1:SiGeBXG331UTiSiXG302X1 1.5653e-26
C_3_82 VSS iQ1:SiGeBXG335UTiSiXG302X1 1.5645e-26
C_3_83 VSS iQ1:SiliconNXG308UTiSiXG301X1 1.3232e-24
C_3_84 VSS iQ1:n1d 2.4800e-23
C_3_85 VSS iQ1:n2s 2.4800e-23
C_3_86 VSS iQ1:n4g 4.0262e-23
C_3_87 VSS iQ1:p1d 2.4049e-23
C_3_88 VSS iQ1:p2g 3.6859e-23
C_3_89 VSS iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 5.6393e-21
C_3_90 VSS iQ2:LM00Cobalt2XG151USiGeBXG294X1 7.2292e-22
C_3_91 VSS iQ2:LM00Cobalt2XG151UTiSiXG305X1 7.2124e-22
C_3_92 VSS iQ2:LM00Cobalt2XG151UTiSiXG306X1 7.2131e-22
C_3_93 VSS iQ2:SDexcludeXG272UTiSiXG305X1 2.2232e-23
C_3_94 VSS iQ2:SDexcludeXG279UTiSiXG306X1 1.1800e-23
C_3_95 VSS iQ2:SDexcludeXG280UTiSiXG306X1 1.1250e-23
C_3_96 VSS iQ2:SiGeBXG294UTiSiXG305X1 1.7213e-24
C_3_97 VSS iQ2:SiGeBXG296UTiSiXG305X1 1.8717e-26
C_3_98 VSS iQ2:SiGeBXG336UTiSiXG305X1 1.8339e-26
C_3_99 VSS iQ2:SiliconNXG311UTiSiXG306X1 1.3358e-24
C_3_100 VSS iQ2:n1g 3.9807e-23
C_3_101 VSS iQ2:n3d 2.4115e-23
C_3_102 VSS iQ2:n4s 2.4115e-23
C_3_103 VSS iQ2:p1g 3.6737e-23
C_3_104 VSS iQ2:p2s 2.3917e-23
C_3_105 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 WLL 2.6430e-20
C_3_106 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 WLR 2.6430e-20
C_3_107 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 1.4994e-21
C_3_108 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 1.2689e-21
C_3_109 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 BLB:SiliconNXG72UTiSiXG71X1 7.9111e-22
C_3_110 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 BLB:n3s 2.1402e-21
C_3_111 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 8.5544e-19
C_3_112 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 BL:LM00Cobalt2XG546UTiSiXG535X1 1.2071e-22
C_3_113 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 BL:SiliconNXG527UTiSiXG535X1 2.4045e-22
C_3_114 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 BL:n2d 1.9473e-21
C_3_115 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 1.0178e-21
C_3_116 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.7698e-23
C_3_117 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 7.7906e-21
C_3_118 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 5.4336e-19
C_3_119 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 3.3986e-20
C_3_120 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 5.4751e-19
C_3_121 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 2.6431e-20
C_3_122 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.3551e-23
C_3_123 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 WL:n2g 9.2396e-22
C_3_124 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 WL:n3g 4.5699e-22
C_3_125 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 7.5783e-20
C_3_126 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 7.3707e-20
C_3_127 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 7.4079e-20
C_3_128 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 7.3691e-20
C_3_129 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:SDexcludeXG271UTiSiXG302X1 5.5998e-22
C_3_130 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:SDexcludeXG277UTiSiXG301X1 1.3394e-21
C_3_131 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:SDexcludeXG278UTiSiXG301X1 9.1471e-22
C_3_132 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:SiGeBXG291UTiSiXG302X1 1.5672e-23
C_3_133 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:SiGeBXG292UTiSiXG302X1 1.9978e-25
C_3_134 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:SiGeBXG331UTiSiXG302X1 1.9155e-25
C_3_135 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:SiGeBXG335UTiSiXG302X1 1.9118e-25
C_3_136 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:SiliconNXG308UTiSiXG301X1 2.1099e-21
C_3_137 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:n1d 3.2001e-21
C_3_138 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:n2s 3.2001e-21
C_3_139 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:n4g 3.5448e-22
C_3_140 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:p1d 5.7527e-22
C_3_141 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ1:p2g 2.1687e-22
C_3_142 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.8292e-18
C_3_143 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 3.1397e-22
C_3_144 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 3.0264e-22
C_3_145 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 3.0267e-22
C_3_146 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:SDexcludeXG272UTiSiXG305X1 3.7025e-22
C_3_147 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.6643e-22
C_3_148 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.5038e-22
C_3_149 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:SiGeBXG294UTiSiXG305X1 1.1392e-23
C_3_150 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:SiGeBXG296UTiSiXG305X1 3.9052e-26
C_3_151 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:SiGeBXG336UTiSiXG305X1 2.9263e-26
C_3_152 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:SiliconNXG311UTiSiXG306X1 9.6811e-24
C_3_153 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:n1g 2.2384e-19
C_3_154 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:n3d 3.2631e-22
C_3_155 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:n4s 3.2631e-22
C_3_156 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:p1g 2.8902e-21
C_3_157 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 iQ2:p2s 3.8159e-22
C_3_158 VSS:LM00Cobalt2XG20UTiSiXG28X1 WLL 5.6268e-22
C_3_159 VSS:LM00Cobalt2XG20UTiSiXG28X1 WLR 5.6268e-22
C_3_160 VSS:LM00Cobalt2XG20UTiSiXG28X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 1.5406e-21
C_3_161 VSS:LM00Cobalt2XG20UTiSiXG28X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 1.3180e-21
C_3_162 VSS:LM00Cobalt2XG20UTiSiXG28X1 BLB:SiliconNXG72UTiSiXG71X1 8.5575e-22
C_3_163 VSS:LM00Cobalt2XG20UTiSiXG28X1 BLB:n3s 2.3380e-21
C_3_164 VSS:LM00Cobalt2XG20UTiSiXG28X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 3.5907e-19
C_3_165 VSS:LM00Cobalt2XG20UTiSiXG28X1 BL:LM00Cobalt2XG546UTiSiXG535X1 8.2633e-23
C_3_166 VSS:LM00Cobalt2XG20UTiSiXG28X1 BL:SiliconNXG527UTiSiXG535X1 2.6075e-22
C_3_167 VSS:LM00Cobalt2XG20UTiSiXG28X1 BL:n2d 2.1140e-21
C_3_168 VSS:LM00Cobalt2XG20UTiSiXG28X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 1.1081e-21
C_3_169 VSS:LM00Cobalt2XG20UTiSiXG28X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.7981e-23
C_3_170 VSS:LM00Cobalt2XG20UTiSiXG28X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 5.7192e-21
C_3_171 VSS:LM00Cobalt2XG20UTiSiXG28X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 2.0018e-20
C_3_172 VSS:LM00Cobalt2XG20UTiSiXG28X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 5.6647e-22
C_3_173 VSS:LM00Cobalt2XG20UTiSiXG28X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.8306e-20
C_3_174 VSS:LM00Cobalt2XG20UTiSiXG28X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 5.6398e-22
C_3_175 VSS:LM00Cobalt2XG20UTiSiXG28X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.3520e-23
C_3_176 VSS:LM00Cobalt2XG20UTiSiXG28X1 WL:n2g 9.9192e-22
C_3_177 VSS:LM00Cobalt2XG20UTiSiXG28X1 WL:n3g 5.0095e-22
C_3_178 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 5.7318e-20
C_3_179 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 5.5053e-20
C_3_180 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 5.5402e-20
C_3_181 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 5.5036e-20
C_3_182 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:SDexcludeXG271UTiSiXG302X1 6.1647e-22
C_3_183 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:SDexcludeXG277UTiSiXG301X1 1.3649e-21
C_3_184 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:SDexcludeXG278UTiSiXG301X1 9.3837e-22
C_3_185 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:SiGeBXG291UTiSiXG302X1 1.7012e-23
C_3_186 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:SiGeBXG292UTiSiXG302X1 1.9739e-25
C_3_187 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:SiGeBXG331UTiSiXG302X1 1.8922e-25
C_3_188 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:SiGeBXG335UTiSiXG302X1 1.8882e-25
C_3_189 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:SiliconNXG308UTiSiXG301X1 2.0469e-21
C_3_190 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:n1d 3.2529e-21
C_3_191 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:n2s 3.2529e-21
C_3_192 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:n4g 3.8775e-22
C_3_193 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:p1d 6.3310e-22
C_3_194 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ1:p2g 2.3735e-22
C_3_195 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.8018e-18
C_3_196 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 3.2077e-22
C_3_197 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 3.0844e-22
C_3_198 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 3.0847e-22
C_3_199 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:SDexcludeXG272UTiSiXG305X1 4.0690e-22
C_3_200 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.8232e-22
C_3_201 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.6457e-22
C_3_202 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:SiGeBXG294UTiSiXG305X1 1.2395e-23
C_3_203 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:SiGeBXG296UTiSiXG305X1 3.9502e-26
C_3_204 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:SiGeBXG336UTiSiXG305X1 2.9657e-26
C_3_205 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:SiliconNXG311UTiSiXG306X1 1.0595e-23
C_3_206 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:n1g 2.3001e-19
C_3_207 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:n3d 3.5730e-22
C_3_208 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:n4s 3.5730e-22
C_3_209 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:p1g 3.3027e-21
C_3_210 VSS:LM00Cobalt2XG20UTiSiXG28X1 iQ2:p2s 4.1924e-22
C_3_211 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 WLL 3.8040e-20
C_3_212 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 WLR 3.8040e-20
C_3_213 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 9.1837e-19
C_3_214 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 1.5973e-22
C_3_215 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 BLB:SiliconNXG72UTiSiXG71X1 2.4178e-22
C_3_216 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 BLB:n3s 1.9499e-21
C_3_217 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 1.5696e-21
C_3_218 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 BL:LM00Cobalt2XG546UTiSiXG535X1 1.3392e-21
C_3_219 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 BL:SiliconNXG527UTiSiXG535X1 7.7519e-22
C_3_220 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 BL:n2d 2.1266e-21
C_3_221 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 1.1756e-20
C_3_222 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 5.3700e-19
C_3_223 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 1.0038e-21
C_3_224 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 1.3557e-23
C_3_225 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 3.8043e-20
C_3_226 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.0257e-23
C_3_227 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 5.3064e-20
C_3_228 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 5.4586e-19
C_3_229 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 WL:n2g 4.5623e-22
C_3_230 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 WL:n3g 9.3843e-22
C_3_231 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 2.8456e-18
C_3_232 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 3.1058e-22
C_3_233 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.9935e-22
C_3_234 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.9930e-22
C_3_235 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:SDexcludeXG271UTiSiXG302X1 3.7095e-22
C_3_236 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:SDexcludeXG277UTiSiXG301X1 1.5044e-22
C_3_237 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:SDexcludeXG278UTiSiXG301X1 1.6647e-22
C_3_238 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:SiGeBXG291UTiSiXG302X1 1.1329e-23
C_3_239 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:SiGeBXG292UTiSiXG302X1 3.2103e-26
C_3_240 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:SiGeBXG331UTiSiXG302X1 2.4932e-26
C_3_241 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:SiGeBXG335UTiSiXG302X1 2.4574e-26
C_3_242 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:SiliconNXG308UTiSiXG301X1 9.7460e-24
C_3_243 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:n1d 3.2646e-22
C_3_244 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:n2s 3.2646e-22
C_3_245 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:n4g 2.2471e-19
C_3_246 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:p1d 3.8223e-22
C_3_247 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ1:p2g 2.8632e-21
C_3_248 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 8.2574e-20
C_3_249 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 8.0494e-20
C_3_250 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 8.0479e-20
C_3_251 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 8.0901e-20
C_3_252 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:SDexcludeXG272UTiSiXG305X1 5.5933e-22
C_3_253 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:SDexcludeXG279UTiSiXG306X1 9.4973e-22
C_3_254 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.3891e-21
C_3_255 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:SiGeBXG294UTiSiXG305X1 1.5749e-23
C_3_256 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:SiGeBXG296UTiSiXG305X1 2.0495e-25
C_3_257 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:SiGeBXG336UTiSiXG305X1 1.9999e-25
C_3_258 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:SiliconNXG311UTiSiXG306X1 2.7190e-21
C_3_259 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:n1g 3.5478e-22
C_3_260 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:n3d 3.7909e-21
C_3_261 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:n4s 3.7909e-21
C_3_262 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:p1g 2.1609e-22
C_3_263 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 iQ2:p2s 5.7468e-22
C_3_264 VSS:LM00Cobalt2XG550UTiSiXG541X1 WLL 5.6687e-22
C_3_265 VSS:LM00Cobalt2XG550UTiSiXG541X1 WLR 5.6687e-22
C_3_266 VSS:LM00Cobalt2XG550UTiSiXG541X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 3.5891e-19
C_3_267 VSS:LM00Cobalt2XG550UTiSiXG541X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 8.2176e-23
C_3_268 VSS:LM00Cobalt2XG550UTiSiXG541X1 BLB:SiliconNXG72UTiSiXG71X1 2.6158e-22
C_3_269 VSS:LM00Cobalt2XG550UTiSiXG541X1 BLB:n3s 2.1157e-21
C_3_270 VSS:LM00Cobalt2XG550UTiSiXG541X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 1.6146e-21
C_3_271 VSS:LM00Cobalt2XG550UTiSiXG541X1 BL:LM00Cobalt2XG546UTiSiXG535X1 1.3919e-21
C_3_272 VSS:LM00Cobalt2XG550UTiSiXG541X1 BL:SiliconNXG527UTiSiXG535X1 8.3905e-22
C_3_273 VSS:LM00Cobalt2XG550UTiSiXG541X1 BL:n2d 2.3239e-21
C_3_274 VSS:LM00Cobalt2XG550UTiSiXG541X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 6.9221e-21
C_3_275 VSS:LM00Cobalt2XG550UTiSiXG541X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.3028e-20
C_3_276 VSS:LM00Cobalt2XG550UTiSiXG541X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 1.0935e-21
C_3_277 VSS:LM00Cobalt2XG550UTiSiXG541X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 1.3854e-23
C_3_278 VSS:LM00Cobalt2XG550UTiSiXG541X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 5.6939e-22
C_3_279 VSS:LM00Cobalt2XG550UTiSiXG541X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.0221e-23
C_3_280 VSS:LM00Cobalt2XG550UTiSiXG541X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 5.7059e-22
C_3_281 VSS:LM00Cobalt2XG550UTiSiXG541X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.0743e-20
C_3_282 VSS:LM00Cobalt2XG550UTiSiXG541X1 WL:n2g 5.0016e-22
C_3_283 VSS:LM00Cobalt2XG550UTiSiXG541X1 WL:n3g 1.0021e-21
C_3_284 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 2.8020e-18
C_3_285 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 3.1720e-22
C_3_286 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 3.0497e-22
C_3_287 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 3.0492e-22
C_3_288 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:SDexcludeXG271UTiSiXG302X1 4.0766e-22
C_3_289 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:SDexcludeXG277UTiSiXG301X1 1.6463e-22
C_3_290 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:SDexcludeXG278UTiSiXG301X1 1.8236e-22
C_3_291 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:SiGeBXG291UTiSiXG302X1 1.2327e-23
C_3_292 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:SiGeBXG292UTiSiXG302X1 3.2476e-26
C_3_293 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:SiGeBXG331UTiSiXG302X1 2.5326e-26
C_3_294 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:SiGeBXG335UTiSiXG302X1 2.4943e-26
C_3_295 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:SiliconNXG308UTiSiXG301X1 1.0666e-23
C_3_296 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:n1d 3.5744e-22
C_3_297 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:n2s 3.5744e-22
C_3_298 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:n4g 2.3088e-19
C_3_299 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:p1d 4.1994e-22
C_3_300 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ1:p2g 3.2713e-21
C_3_301 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 5.5426e-20
C_3_302 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 5.3158e-20
C_3_303 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 5.3141e-20
C_3_304 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 5.3519e-20
C_3_305 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:SDexcludeXG272UTiSiXG305X1 6.1575e-22
C_3_306 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:SDexcludeXG279UTiSiXG306X1 9.5073e-22
C_3_307 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.3871e-21
C_3_308 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:SiGeBXG294UTiSiXG305X1 1.7100e-23
C_3_309 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:SiGeBXG296UTiSiXG305X1 2.0406e-25
C_3_310 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:SiGeBXG336UTiSiXG305X1 1.9920e-25
C_3_311 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:SiliconNXG311UTiSiXG306X1 2.5552e-21
C_3_312 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:n1g 3.8804e-22
C_3_313 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:n3d 3.7603e-21
C_3_314 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:n4s 3.7603e-21
C_3_315 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:p1g 2.3650e-22
C_3_316 VSS:LM00Cobalt2XG550UTiSiXG541X1 iQ2:p2s 6.3245e-22
C_3_317 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 WLL 3.0690e-19
C_3_318 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 WLR 3.0690e-19
C_3_319 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 4.2259e-23
C_3_320 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 1.4859e-23
C_3_321 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 BLB:SiliconNXG72UTiSiXG71X1 3.4609e-24
C_3_322 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 BLB:n3s 5.7369e-24
C_3_323 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 1.5139e-19
C_3_324 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 BL:LM00Cobalt2XG546UTiSiXG535X1 9.9545e-25
C_3_325 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 BL:SiliconNXG527UTiSiXG535X1 4.5714e-25
C_3_326 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 BL:n2d 2.8589e-24
C_3_327 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 3.1366e-24
C_3_328 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.8868e-24
C_3_329 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 2.7575e-24
C_3_330 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 2.1105e-20
C_3_331 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 3.1267e-19
C_3_332 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 2.6878e-20
C_3_333 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 3.0690e-19
C_3_334 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 7.5799e-24
C_3_335 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 WL:n2g 1.1338e-24
C_3_336 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 WL:n3g 7.2596e-25
C_3_337 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 1.6391e-23
C_3_338 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.3713e-23
C_3_339 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 1.3706e-23
C_3_340 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 1.3696e-23
C_3_341 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:SDexcludeXG271UTiSiXG302X1 7.7005e-25
C_3_342 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:SDexcludeXG277UTiSiXG301X1 8.8368e-25
C_3_343 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:SDexcludeXG278UTiSiXG301X1 6.8885e-25
C_3_344 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:SiGeBXG291UTiSiXG302X1 1.7913e-26
C_3_345 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:SiGeBXG292UTiSiXG302X1 1.4823e-28
C_3_346 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:SiGeBXG331UTiSiXG302X1 1.2961e-28
C_3_347 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:SiGeBXG335UTiSiXG302X1 1.2911e-28
C_3_348 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:SiliconNXG308UTiSiXG301X1 1.3632e-25
C_3_349 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:n1d 1.6770e-24
C_3_350 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:n2s 1.6770e-24
C_3_351 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:n4g 3.9042e-25
C_3_352 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:p1d 7.8771e-25
C_3_353 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ1:p2g 2.7991e-25
C_3_354 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.7336e-22
C_3_355 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.6707e-24
C_3_356 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.6504e-24
C_3_357 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.6506e-24
C_3_358 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:SDexcludeXG272UTiSiXG305X1 5.3894e-25
C_3_359 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:SDexcludeXG279UTiSiXG306X1 2.1266e-25
C_3_360 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.8388e-25
C_3_361 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:SiGeBXG294UTiSiXG305X1 2.0441e-26
C_3_362 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:SiGeBXG296UTiSiXG305X1 1.0480e-28
C_3_363 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:SiGeBXG336UTiSiXG305X1 6.5718e-29
C_3_364 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:SiliconNXG311UTiSiXG306X1 1.4568e-26
C_3_365 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:n1g 9.2889e-24
C_3_366 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:n3d 4.1041e-25
C_3_367 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:n4s 4.1041e-25
C_3_368 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:p1g 2.0788e-24
C_3_369 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 iQ2:p2s 5.5925e-25
C_3_370 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 WLL 7.3971e-20
C_3_371 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 WLR 7.3971e-20
C_3_372 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 5.6429e-23
C_3_373 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 3.6406e-23
C_3_374 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 BLB:SiliconNXG72UTiSiXG71X1 1.3986e-23
C_3_375 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 BLB:n3s 3.4482e-23
C_3_376 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 5.7563e-19
C_3_377 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 BL:LM00Cobalt2XG546UTiSiXG535X1 4.0961e-23
C_3_378 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 BL:SiliconNXG527UTiSiXG535X1 4.2663e-24
C_3_379 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 BL:n2d 3.1179e-23
C_3_380 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 1.7158e-23
C_3_381 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 8.9265e-25
C_3_382 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 2.2140e-21
C_3_383 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 5.3986e-19
C_3_384 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 8.5693e-20
C_3_385 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 5.4989e-19
C_3_386 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 7.3971e-20
C_3_387 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 9.0909e-25
C_3_388 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 WL:n2g 1.6564e-23
C_3_389 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 WL:n3g 7.0704e-24
C_3_390 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 1.8721e-20
C_3_391 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.8689e-20
C_3_392 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 1.8712e-20
C_3_393 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 1.8689e-20
C_3_394 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:SDexcludeXG271UTiSiXG302X1 8.5495e-24
C_3_395 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:SDexcludeXG277UTiSiXG301X1 4.2896e-23
C_3_396 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:SDexcludeXG278UTiSiXG301X1 3.2318e-23
C_3_397 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:SiGeBXG291UTiSiXG302X1 2.3090e-25
C_3_398 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:SiGeBXG292UTiSiXG302X1 2.9626e-27
C_3_399 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:SiGeBXG331UTiSiXG302X1 2.8608e-27
C_3_400 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:SiGeBXG335UTiSiXG302X1 2.8543e-27
C_3_401 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:SiliconNXG308UTiSiXG301X1 7.9940e-23
C_3_402 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:n1d 8.3725e-23
C_3_403 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:n2s 8.3725e-23
C_3_404 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:n4g 5.4905e-24
C_3_405 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:p1d 8.7746e-24
C_3_406 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ1:p2g 3.3554e-24
C_3_407 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 6.3909e-20
C_3_408 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 7.5085e-24
C_3_409 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 7.3414e-24
C_3_410 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 7.3422e-24
C_3_411 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:SDexcludeXG272UTiSiXG305X1 5.6509e-24
C_3_412 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:SDexcludeXG279UTiSiXG306X1 2.5718e-24
C_3_413 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:SDexcludeXG280UTiSiXG306X1 2.3361e-24
C_3_414 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:SiGeBXG294UTiSiXG305X1 1.6773e-25
C_3_415 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:SiGeBXG296UTiSiXG305X1 3.7865e-28
C_3_416 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:SiGeBXG336UTiSiXG305X1 3.3250e-28
C_3_417 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:SiliconNXG311UTiSiXG306X1 1.5040e-25
C_3_418 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:n1g 3.6884e-22
C_3_419 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:n3d 5.0550e-24
C_3_420 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:n4s 5.0550e-24
C_3_421 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:p1g 1.8264e-23
C_3_422 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 iQ2:p2s 5.8180e-24
C_3_423 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 WLL 3.1852e-19
C_3_424 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 WLR 3.1852e-19
C_3_425 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 1.4710e-19
C_3_426 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 1.0602e-24
C_3_427 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 BLB:SiliconNXG72UTiSiXG71X1 4.3112e-25
C_3_428 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 BLB:n3s 2.4625e-24
C_3_429 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 3.8963e-23
C_3_430 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 BL:LM00Cobalt2XG546UTiSiXG535X1 1.4610e-23
C_3_431 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 BL:SiliconNXG527UTiSiXG535X1 3.2170e-24
C_3_432 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 BL:n2d 5.4729e-24
C_3_433 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 2.6626e-24
C_3_434 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.0617e-20
C_3_435 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 2.9659e-24
C_3_436 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 8.3368e-25
C_3_437 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 3.1853e-19
C_3_438 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 5.8916e-24
C_3_439 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 3.2410e-19
C_3_440 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.6197e-20
C_3_441 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 WL:n2g 7.4369e-25
C_3_442 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 WL:n3g 1.0229e-24
C_3_443 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 1.6890e-22
C_3_444 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.5507e-24
C_3_445 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.5318e-24
C_3_446 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.5316e-24
C_3_447 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:SDexcludeXG271UTiSiXG302X1 5.0371e-25
C_3_448 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:SDexcludeXG277UTiSiXG301X1 2.0252e-25
C_3_449 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:SDexcludeXG278UTiSiXG301X1 2.2676e-25
C_3_450 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:SiGeBXG291UTiSiXG302X1 1.9236e-26
C_3_451 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:SiGeBXG292UTiSiXG302X1 8.8372e-29
C_3_452 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:SiGeBXG331UTiSiXG302X1 6.3628e-29
C_3_453 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:SiGeBXG335UTiSiXG302X1 6.3176e-29
C_3_454 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:SiliconNXG308UTiSiXG301X1 1.5380e-26
C_3_455 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:n1d 4.4381e-25
C_3_456 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:n2s 4.4381e-25
C_3_457 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:n4g 8.9373e-24
C_3_458 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:p1d 5.2282e-25
C_3_459 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ1:p2g 1.8811e-24
C_3_460 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.6005e-23
C_3_461 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 1.3232e-23
C_3_462 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 1.3213e-23
C_3_463 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 1.3224e-23
C_3_464 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:SDexcludeXG272UTiSiXG305X1 7.1341e-25
C_3_465 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:SDexcludeXG279UTiSiXG306X1 6.4691e-25
C_3_466 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:SDexcludeXG280UTiSiXG306X1 8.3818e-25
C_3_467 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:SiGeBXG294UTiSiXG305X1 1.9213e-26
C_3_468 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:SiGeBXG296UTiSiXG305X1 1.5587e-28
C_3_469 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:SiGeBXG336UTiSiXG305X1 1.3824e-28
C_3_470 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:SiliconNXG311UTiSiXG306X1 1.3445e-25
C_3_471 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:n1g 4.6787e-25
C_3_472 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:n3d 1.5869e-24
C_3_473 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:n4s 1.5869e-24
C_3_474 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:p1g 3.5103e-25
C_3_475 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 iQ2:p2s 7.3235e-25
C_3_476 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 WLL 8.7626e-20
C_3_477 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 WLR 8.7626e-20
C_3_478 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 6.3791e-19
C_3_479 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 8.0314e-23
C_3_480 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 BLB:SiliconNXG72UTiSiXG71X1 4.8554e-24
C_3_481 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 BLB:n3s 3.2172e-23
C_3_482 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 5.7759e-23
C_3_483 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 BL:LM00Cobalt2XG546UTiSiXG535X1 3.8154e-23
C_3_484 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 BL:SiliconNXG527UTiSiXG535X1 1.3687e-23
C_3_485 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 BL:n2d 3.4255e-23
C_3_486 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 4.9772e-21
C_3_487 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 5.3218e-19
C_3_488 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 1.6897e-23
C_3_489 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 6.1724e-25
C_3_490 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 8.7627e-20
C_3_491 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 6.8783e-25
C_3_492 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 1.0675e-19
C_3_493 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 5.4743e-19
C_3_494 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 WL:n2g 7.0539e-24
C_3_495 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 WL:n3g 2.0869e-23
C_3_496 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 8.0414e-20
C_3_497 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 7.4929e-24
C_3_498 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 7.3266e-24
C_3_499 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 7.3256e-24
C_3_500 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:SDexcludeXG271UTiSiXG302X1 5.6572e-24
C_3_501 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:SDexcludeXG277UTiSiXG301X1 2.3381e-24
C_3_502 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:SDexcludeXG278UTiSiXG301X1 2.5746e-24
C_3_503 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:SiGeBXG291UTiSiXG302X1 1.6795e-25
C_3_504 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:SiGeBXG292UTiSiXG302X1 3.6988e-28
C_3_505 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:SiGeBXG331UTiSiXG302X1 3.1098e-28
C_3_506 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:SiGeBXG335UTiSiXG302X1 3.0437e-28
C_3_507 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:SiliconNXG308UTiSiXG301X1 1.5249e-25
C_3_508 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:n1d 5.0613e-24
C_3_509 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:n2s 5.0613e-24
C_3_510 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:n4g 4.5049e-22
C_3_511 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:p1d 5.8246e-24
C_3_512 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ1:p2g 1.8314e-23
C_3_513 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.7402e-20
C_3_514 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.7369e-20
C_3_515 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.7368e-20
C_3_516 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.7414e-20
C_3_517 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:SDexcludeXG272UTiSiXG305X1 8.5453e-24
C_3_518 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:SDexcludeXG279UTiSiXG306X1 5.4719e-23
C_3_519 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:SDexcludeXG280UTiSiXG306X1 6.9993e-23
C_3_520 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:SiGeBXG294UTiSiXG305X1 2.2852e-25
C_3_521 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:SiGeBXG296UTiSiXG305X1 1.4521e-27
C_3_522 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:SiGeBXG336UTiSiXG305X1 1.2846e-27
C_3_523 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:SiliconNXG311UTiSiXG306X1 1.8183e-22
C_3_524 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:n1g 5.5211e-24
C_3_525 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:n3d 1.6829e-22
C_3_526 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:n4s 1.6829e-22
C_3_527 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:p1g 3.3532e-24
C_3_528 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 iQ2:p2s 8.7712e-24
C_3_529 VSS:SiliconNXG29UTiSiXG28X1 WLL 4.4848e-23
C_3_530 VSS:SiliconNXG29UTiSiXG28X1 WLR 4.4848e-23
C_3_531 VSS:SiliconNXG29UTiSiXG28X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 1.3477e-21
C_3_532 VSS:SiliconNXG29UTiSiXG28X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 1.2806e-21
C_3_533 VSS:SiliconNXG29UTiSiXG28X1 BLB:SiliconNXG72UTiSiXG71X1 2.7015e-21
C_3_534 VSS:SiliconNXG29UTiSiXG28X1 BLB:n3s 1.3168e-20
C_3_535 VSS:SiliconNXG29UTiSiXG28X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 1.0966e-20
C_3_536 VSS:SiliconNXG29UTiSiXG28X1 BL:LM00Cobalt2XG546UTiSiXG535X1 2.4835e-22
C_3_537 VSS:SiliconNXG29UTiSiXG28X1 BL:SiliconNXG527UTiSiXG535X1 2.2698e-21
C_3_538 VSS:SiliconNXG29UTiSiXG28X1 BL:n2d 1.8477e-20
C_3_539 VSS:SiliconNXG29UTiSiXG28X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 6.2021e-21
C_3_540 VSS:SiliconNXG29UTiSiXG28X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 2.2955e-23
C_3_541 VSS:SiliconNXG29UTiSiXG28X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 1.4115e-20
C_3_542 VSS:SiliconNXG29UTiSiXG28X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 1.1747e-22
C_3_543 VSS:SiliconNXG29UTiSiXG28X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 4.5530e-23
C_3_544 VSS:SiliconNXG29UTiSiXG28X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 7.6560e-23
C_3_545 VSS:SiliconNXG29UTiSiXG28X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 4.5437e-23
C_3_546 VSS:SiliconNXG29UTiSiXG28X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.1712e-23
C_3_547 VSS:SiliconNXG29UTiSiXG28X1 WL:n2g 8.3999e-23
C_3_548 VSS:SiliconNXG29UTiSiXG28X1 WL:n3g 5.0650e-23
C_3_549 VSS:SiliconNXG29UTiSiXG28X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 1.5478e-20
C_3_550 VSS:SiliconNXG29UTiSiXG28X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.0493e-21
C_3_551 VSS:SiliconNXG29UTiSiXG28X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 1.0462e-21
C_3_552 VSS:SiliconNXG29UTiSiXG28X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 9.1327e-22
C_3_553 VSS:SiliconNXG29UTiSiXG28X1 iQ1:SDexcludeXG271UTiSiXG302X1 5.4504e-21
C_3_554 VSS:SiliconNXG29UTiSiXG28X1 iQ1:SDexcludeXG277UTiSiXG301X1 7.2631e-21
C_3_555 VSS:SiliconNXG29UTiSiXG28X1 iQ1:SDexcludeXG278UTiSiXG301X1 5.5669e-21
C_3_556 VSS:SiliconNXG29UTiSiXG28X1 iQ1:SiGeBXG291UTiSiXG302X1 1.3601e-22
C_3_557 VSS:SiliconNXG29UTiSiXG28X1 iQ1:SiGeBXG292UTiSiXG302X1 1.9460e-26
C_3_558 VSS:SiliconNXG29UTiSiXG28X1 iQ1:SiGeBXG331UTiSiXG302X1 1.9790e-26
C_3_559 VSS:SiliconNXG29UTiSiXG28X1 iQ1:SiGeBXG335UTiSiXG302X1 1.6425e-26
C_3_560 VSS:SiliconNXG29UTiSiXG28X1 iQ1:SiliconNXG308UTiSiXG301X1 1.8132e-21
C_3_561 VSS:SiliconNXG29UTiSiXG28X1 iQ1:n1d 1.4244e-20
C_3_562 VSS:SiliconNXG29UTiSiXG28X1 iQ1:n2s 1.4244e-20
C_3_563 VSS:SiliconNXG29UTiSiXG28X1 iQ1:n4g 3.8517e-23
C_3_564 VSS:SiliconNXG29UTiSiXG28X1 iQ1:p1d 5.5864e-21
C_3_565 VSS:SiliconNXG29UTiSiXG28X1 iQ1:p2g 2.3698e-23
C_3_566 VSS:SiliconNXG29UTiSiXG28X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.0136e-18
C_3_567 VSS:SiliconNXG29UTiSiXG28X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.3501e-22
C_3_568 VSS:SiliconNXG29UTiSiXG28X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 1.4963e-22
C_3_569 VSS:SiliconNXG29UTiSiXG28X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 1.4983e-22
C_3_570 VSS:SiliconNXG29UTiSiXG28X1 iQ2:SDexcludeXG272UTiSiXG305X1 3.3065e-21
C_3_571 VSS:SiliconNXG29UTiSiXG28X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.5000e-21
C_3_572 VSS:SiliconNXG29UTiSiXG28X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.3739e-21
C_3_573 VSS:SiliconNXG29UTiSiXG28X1 iQ2:SiGeBXG294UTiSiXG305X1 8.5413e-23
C_3_574 VSS:SiliconNXG29UTiSiXG28X1 iQ2:SiGeBXG296UTiSiXG305X1 1.9447e-26
C_3_575 VSS:SiliconNXG29UTiSiXG28X1 iQ2:SiGeBXG336UTiSiXG305X1 1.6175e-26
C_3_576 VSS:SiliconNXG29UTiSiXG28X1 iQ2:SiliconNXG311UTiSiXG306X1 8.2819e-23
C_3_577 VSS:SiliconNXG29UTiSiXG28X1 iQ2:n1g 6.5354e-21
C_3_578 VSS:SiliconNXG29UTiSiXG28X1 iQ2:n3d 2.9561e-21
C_3_579 VSS:SiliconNXG29UTiSiXG28X1 iQ2:n4s 2.9561e-21
C_3_580 VSS:SiliconNXG29UTiSiXG28X1 iQ2:p1g 4.2971e-22
C_3_581 VSS:SiliconNXG29UTiSiXG28X1 iQ2:p2s 3.3919e-21
C_3_582 VSS:SiliconNXG530UTiSiXG541X1 WLL 4.5047e-23
C_3_583 VSS:SiliconNXG530UTiSiXG541X1 WLR 4.5047e-23
C_3_584 VSS:SiliconNXG530UTiSiXG541X1 BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 1.0940e-20
C_3_585 VSS:SiliconNXG530UTiSiXG541X1 BLB:LM00Cobalt2XG70UTiSiXG71X1 2.3723e-22
C_3_586 VSS:SiliconNXG530UTiSiXG541X1 BLB:SiliconNXG72UTiSiXG71X1 2.2767e-21
C_3_587 VSS:SiliconNXG530UTiSiXG541X1 BLB:n3s 1.8491e-20
C_3_588 VSS:SiliconNXG530UTiSiXG541X1 BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 1.4320e-21
C_3_589 VSS:SiliconNXG530UTiSiXG541X1 BL:LM00Cobalt2XG546UTiSiXG535X1 1.3632e-21
C_3_590 VSS:SiliconNXG530UTiSiXG541X1 BL:SiliconNXG527UTiSiXG535X1 2.6800e-21
C_3_591 VSS:SiliconNXG530UTiSiXG541X1 BL:n2d 1.3159e-20
C_3_592 VSS:SiliconNXG530UTiSiXG541X1 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 1.4215e-20
C_3_593 VSS:SiliconNXG530UTiSiXG541X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.1082e-22
C_3_594 VSS:SiliconNXG530UTiSiXG541X1 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 6.1933e-21
C_3_595 VSS:SiliconNXG530UTiSiXG541X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 1.9644e-23
C_3_596 VSS:SiliconNXG530UTiSiXG541X1 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 4.6524e-23
C_3_597 VSS:SiliconNXG530UTiSiXG541X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 8.7529e-24
C_3_598 VSS:SiliconNXG530UTiSiXG541X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 4.5329e-23
C_3_599 VSS:SiliconNXG530UTiSiXG541X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 5.5986e-23
C_3_600 VSS:SiliconNXG530UTiSiXG541X1 WL:n2g 5.0618e-23
C_3_601 VSS:SiliconNXG530UTiSiXG541X1 WL:n3g 8.4031e-23
C_3_602 VSS:SiliconNXG530UTiSiXG541X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 2.0238e-18
C_3_603 VSS:SiliconNXG530UTiSiXG541X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.3131e-22
C_3_604 VSS:SiliconNXG530UTiSiXG541X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 1.4642e-22
C_3_605 VSS:SiliconNXG530UTiSiXG541X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 1.4613e-22
C_3_606 VSS:SiliconNXG530UTiSiXG541X1 iQ1:SDexcludeXG271UTiSiXG302X1 3.3136e-21
C_3_607 VSS:SiliconNXG530UTiSiXG541X1 iQ1:SDexcludeXG277UTiSiXG301X1 1.3747e-21
C_3_608 VSS:SiliconNXG530UTiSiXG541X1 iQ1:SDexcludeXG278UTiSiXG301X1 1.5006e-21
C_3_609 VSS:SiliconNXG530UTiSiXG541X1 iQ1:SiGeBXG291UTiSiXG302X1 8.5210e-23
C_3_610 VSS:SiliconNXG530UTiSiXG541X1 iQ1:SiGeBXG292UTiSiXG302X1 1.6713e-26
C_3_611 VSS:SiliconNXG530UTiSiXG541X1 iQ1:SiGeBXG331UTiSiXG302X1 1.9648e-26
C_3_612 VSS:SiliconNXG530UTiSiXG541X1 iQ1:SiGeBXG335UTiSiXG302X1 1.6396e-26
C_3_613 VSS:SiliconNXG530UTiSiXG541X1 iQ1:SiliconNXG308UTiSiXG301X1 8.3512e-23
C_3_614 VSS:SiliconNXG530UTiSiXG541X1 iQ1:n1d 2.9578e-21
C_3_615 VSS:SiliconNXG530UTiSiXG541X1 iQ1:n2s 2.9578e-21
C_3_616 VSS:SiliconNXG530UTiSiXG541X1 iQ1:n4g 6.6139e-21
C_3_617 VSS:SiliconNXG530UTiSiXG541X1 iQ1:p1d 3.3988e-21
C_3_618 VSS:SiliconNXG530UTiSiXG541X1 iQ1:p2g 4.2544e-22
C_3_619 VSS:SiliconNXG530UTiSiXG541X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.5314e-20
C_3_620 VSS:SiliconNXG530UTiSiXG541X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 8.6786e-22
C_3_621 VSS:SiliconNXG530UTiSiXG541X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 7.3127e-22
C_3_622 VSS:SiliconNXG530UTiSiXG541X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 8.3768e-22
C_3_623 VSS:SiliconNXG530UTiSiXG541X1 iQ2:SDexcludeXG272UTiSiXG305X1 5.4461e-21
C_3_624 VSS:SiliconNXG530UTiSiXG541X1 iQ2:SDexcludeXG279UTiSiXG306X1 5.5456e-21
C_3_625 VSS:SiliconNXG530UTiSiXG541X1 iQ2:SDexcludeXG280UTiSiXG306X1 7.2455e-21
C_3_626 VSS:SiliconNXG530UTiSiXG541X1 iQ2:SiGeBXG294UTiSiXG305X1 1.3662e-22
C_3_627 VSS:SiliconNXG530UTiSiXG541X1 iQ2:SiGeBXG296UTiSiXG305X1 1.5315e-26
C_3_628 VSS:SiliconNXG530UTiSiXG541X1 iQ2:SiGeBXG336UTiSiXG305X1 1.3909e-26
C_3_629 VSS:SiliconNXG530UTiSiXG541X1 iQ2:SiliconNXG311UTiSiXG306X1 1.9561e-21
C_3_630 VSS:SiliconNXG530UTiSiXG541X1 iQ2:n1g 3.8542e-23
C_3_631 VSS:SiliconNXG530UTiSiXG541X1 iQ2:n3d 1.4428e-20
C_3_632 VSS:SiliconNXG530UTiSiXG541X1 iQ2:n4s 1.4428e-20
C_3_633 VSS:SiliconNXG530UTiSiXG541X1 iQ2:p1g 2.3612e-23
C_3_634 VSS:SiliconNXG530UTiSiXG541X1 iQ2:p2s 5.5827e-21
C_3_635 VSS:n1s WLL 4.7070e-23
C_3_636 VSS:n1s WLR 4.7070e-23
C_3_637 VSS:n1s BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 3.3582e-21
C_3_638 VSS:n1s BLB:LM00Cobalt2XG70UTiSiXG71X1 3.2810e-21
C_3_639 VSS:n1s BLB:SiliconNXG72UTiSiXG71X1 1.4422e-20
C_3_640 VSS:n1s BLB:n3s 9.0070e-20
C_3_641 VSS:n1s BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 1.2747e-20
C_3_642 VSS:n1s BL:LM00Cobalt2XG546UTiSiXG535X1 2.1189e-21
C_3_643 VSS:n1s BL:SiliconNXG527UTiSiXG535X1 1.9682e-20
C_3_644 VSS:n1s BL:n2d 1.6414e-19
C_3_645 VSS:n1s WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 4.3081e-20
C_3_646 VSS:n1s WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 1.0620e-22
C_3_647 VSS:n1s WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 1.1932e-19
C_3_648 VSS:n1s WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 2.7459e-22
C_3_649 VSS:n1s WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 5.1549e-23
C_3_650 VSS:n1s WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.3684e-22
C_3_651 VSS:n1s WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 4.8394e-23
C_3_652 VSS:n1s WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 4.3256e-23
C_3_653 VSS:n1s iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 1.1949e-19
C_3_654 VSS:n1s iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.5161e-21
C_3_655 VSS:n1s iQ1:LM00Cobalt2XG314UTiSiXG301X1 1.4615e-21
C_3_656 VSS:n1s iQ1:LM00Cobalt2XG314UTiSiXG302X1 1.2743e-21
C_3_657 VSS:n1s iQ1:SDexcludeXG271UTiSiXG302X1 4.5179e-20
C_3_658 VSS:n1s iQ1:SDexcludeXG277UTiSiXG301X1 1.0825e-19
C_3_659 VSS:n1s iQ1:SDexcludeXG278UTiSiXG301X1 9.8982e-20
C_3_660 VSS:n1s iQ1:SiGeBXG291UTiSiXG302X1 1.2421e-21
C_3_661 VSS:n1s iQ1:SiGeBXG292UTiSiXG302X1 1.3816e-25
C_3_662 VSS:n1s iQ1:SiGeBXG331UTiSiXG302X1 1.5266e-25
C_3_663 VSS:n1s iQ1:SiGeBXG335UTiSiXG302X1 1.2632e-25
C_3_664 VSS:n1s iQ1:SiliconNXG308UTiSiXG301X1 6.2155e-21
C_3_665 VSS:n1s iQ1:n1d 2.1288e-19
C_3_666 VSS:n1s iQ1:n2s 2.1288e-19
C_3_667 VSS:n1s iQ1:p1d 4.6421e-20
C_3_668 VSS:n1s iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 5.2899e-18
C_3_669 VSS:n1s iQ2:LM00Cobalt2XG151USiGeBXG294X1 9.0966e-22
C_3_670 VSS:n1s iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.6776e-22
C_3_671 VSS:n1s iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.6908e-22
C_3_672 VSS:n1s iQ2:SDexcludeXG272UTiSiXG305X1 2.5150e-20
C_3_673 VSS:n1s iQ2:SDexcludeXG279UTiSiXG306X1 1.1626e-20
C_3_674 VSS:n1s iQ2:SDexcludeXG280UTiSiXG306X1 1.0754e-20
C_3_675 VSS:n1s iQ2:SiGeBXG294UTiSiXG305X1 6.4202e-22
C_3_676 VSS:n1s iQ2:SiGeBXG296UTiSiXG305X1 9.5228e-26
C_3_677 VSS:n1s iQ2:SiGeBXG336UTiSiXG305X1 6.5478e-26
C_3_678 VSS:n1s iQ2:SiliconNXG311UTiSiXG306X1 6.3561e-22
C_3_679 VSS:n1s iQ2:n3d 2.3012e-20
C_3_680 VSS:n1s iQ2:n4s 2.3012e-20
C_3_681 VSS:n1s iQ2:p2s 2.5791e-20
C_3_682 VSS:n4d WLL 4.7226e-23
C_3_683 VSS:n4d WLR 4.7226e-23
C_3_684 VSS:n4d BLB:LM00Cobalt2XG70ULM40Cobalt5XG76X1 1.2634e-20
C_3_685 VSS:n4d BLB:LM00Cobalt2XG70UTiSiXG71X1 2.0236e-21
C_3_686 VSS:n4d BLB:SiliconNXG72UTiSiXG71X1 1.9732e-20
C_3_687 VSS:n4d BLB:n3s 1.6417e-19
C_3_688 VSS:n4d BL:LM00Cobalt2XG546ULM40Cobalt5XG45X1 3.5621e-21
C_3_689 VSS:n4d BL:LM00Cobalt2XG546UTiSiXG535X1 3.4785e-21
C_3_690 VSS:n4d BL:SiliconNXG527UTiSiXG535X1 1.4351e-20
C_3_691 VSS:n4d BL:n2d 9.0029e-20
C_3_692 VSS:n4d WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 1.1941e-19
C_3_693 VSS:n4d WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 2.7513e-22
C_3_694 VSS:n4d WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 4.3062e-20
C_3_695 VSS:n4d WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 9.4803e-23
C_3_696 VSS:n4d WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 5.1607e-23
C_3_697 VSS:n4d WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 3.2511e-23
C_3_698 VSS:n4d WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 4.8484e-23
C_3_699 VSS:n4d WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.2004e-22
C_3_700 VSS:n4d iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 5.2921e-18
C_3_701 VSS:n4d iQ1:LM00Cobalt2XG314USiGeBXG291X1 8.9576e-22
C_3_702 VSS:n4d iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.5756e-22
C_3_703 VSS:n4d iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.5559e-22
C_3_704 VSS:n4d iQ1:SDexcludeXG271UTiSiXG302X1 2.5187e-20
C_3_705 VSS:n4d iQ1:SDexcludeXG277UTiSiXG301X1 1.0754e-20
C_3_706 VSS:n4d iQ1:SDexcludeXG278UTiSiXG301X1 1.1624e-20
C_3_707 VSS:n4d iQ1:SiGeBXG291UTiSiXG302X1 6.4031e-22
C_3_708 VSS:n4d iQ1:SiGeBXG292UTiSiXG302X1 8.7406e-26
C_3_709 VSS:n4d iQ1:SiGeBXG331UTiSiXG302X1 1.0133e-25
C_3_710 VSS:n4d iQ1:SiGeBXG335UTiSiXG302X1 7.5816e-26
C_3_711 VSS:n4d iQ1:SiliconNXG308UTiSiXG301X1 6.4056e-22
C_3_712 VSS:n4d iQ1:n1d 2.3012e-20
C_3_713 VSS:n4d iQ1:n2s 2.3012e-20
C_3_714 VSS:n4d iQ1:p1d 2.5827e-20
C_3_715 VSS:n4d iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.1931e-19
C_3_716 VSS:n4d iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.2909e-21
C_3_717 VSS:n4d iQ2:LM00Cobalt2XG151UTiSiXG305X1 1.0441e-21
C_3_718 VSS:n4d iQ2:LM00Cobalt2XG151UTiSiXG306X1 1.1897e-21
C_3_719 VSS:n4d iQ2:SDexcludeXG272UTiSiXG305X1 4.5106e-20
C_3_720 VSS:n4d iQ2:SDexcludeXG279UTiSiXG306X1 9.9015e-20
C_3_721 VSS:n4d iQ2:SDexcludeXG280UTiSiXG306X1 1.0890e-19
C_3_722 VSS:n4d iQ2:SiGeBXG294UTiSiXG305X1 1.2470e-21
C_3_723 VSS:n4d iQ2:SiGeBXG296UTiSiXG305X1 1.2375e-25
C_3_724 VSS:n4d iQ2:SiGeBXG336UTiSiXG305X1 1.1628e-25
C_3_725 VSS:n4d iQ2:SiliconNXG311UTiSiXG306X1 6.3824e-21
C_3_726 VSS:n4d iQ2:n3d 2.1386e-19
C_3_727 VSS:n4d iQ2:n4s 2.1386e-19
C_3_728 VSS:n4d iQ2:p2s 4.6352e-20
R_3_0 VSS VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 4.2950e+01
R_3_1 VSS VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 4.3238e+01
R_3_2 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 VSS:LM00Cobalt2XG20UTiSiXG28X1 9.9187e+01
R_3_3 VSS:LM00Cobalt2XG20ULM40Cobalt5XG24X1 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 9.7191e+01
R_3_4 VSS:LM00Cobalt2XG20UTiSiXG28X1 VSS:SiliconNXG29UTiSiXG28X1 1.2814e+02
R_3_5 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 VSS:LM00Cobalt2XG550UTiSiXG541X1 9.9197e+01
R_3_6 VSS:LM00Cobalt2XG550ULM40Cobalt5XG379X1 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 9.5721e+01
R_3_7 VSS:LM00Cobalt2XG550UTiSiXG541X1 VSS:SiliconNXG530UTiSiXG541X1 1.2710e+02
R_3_8 VSS:LM20Cobalt3XG27ULM30Cobalt4XG12X1 VSS:LM20Cobalt3XG27ULM40Cobalt5XG24X1 3.5193e+01
R_3_9 VSS:LM20Cobalt3XG518ULM30Cobalt4XG520X1 VSS:LM20Cobalt3XG518ULM40Cobalt5XG379X1 3.5219e+01
R_3_10 VSS:SiliconNXG29UTiSiXG28X1 VSS:n1s 1.9151e+01
R_3_11 VSS:SiliconNXG530UTiSiXG541X1 VSS:n4d 2.0956e+01

*|NET WL 1.2299e-04PF
C_4_0 WLL iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 3.3974e-22
C_4_1 WLL iQ1:LM00Cobalt2XG314USiGeBXG291X1 6.9332e-23
C_4_2 WLL iQ1:LM00Cobalt2XG314UTiSiXG301X1 6.9249e-23
C_4_3 WLL iQ1:LM00Cobalt2XG314UTiSiXG302X1 6.9244e-23
C_4_4 WLL iQ1:SDexcludeXG271UTiSiXG302X1 1.0536e-24
C_4_5 WLL iQ1:SDexcludeXG277UTiSiXG301X1 5.0099e-25
C_4_6 WLL iQ1:SDexcludeXG278UTiSiXG301X1 5.1682e-25
C_4_7 WLL iQ1:SiGeBXG291UTiSiXG302X1 9.0696e-26
C_4_8 WLL iQ1:SiGeBXG292UTiSiXG302X1 1.1529e-27
C_4_9 WLL iQ1:SiGeBXG331UTiSiXG302X1 1.0466e-27
C_4_10 WLL iQ1:SiGeBXG335UTiSiXG302X1 1.0462e-27
C_4_11 WLL iQ1:SiliconNXG308UTiSiXG301X1 6.4711e-26
C_4_12 WLL iQ1:n1d 1.0653e-24
C_4_13 WLL iQ1:n2s 1.0653e-24
C_4_14 WLL iQ1:n4g 1.7571e-24
C_4_15 WLL iQ1:p1d 1.1422e-24
C_4_16 WLL iQ1:p2g 1.7907e-24
C_4_17 WLL iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 3.4487e-22
C_4_18 WLL iQ2:LM00Cobalt2XG151USiGeBXG294X1 6.9612e-23
C_4_19 WLL iQ2:LM00Cobalt2XG151UTiSiXG305X1 6.9523e-23
C_4_20 WLL iQ2:LM00Cobalt2XG151UTiSiXG306X1 6.9528e-23
C_4_21 WLL iQ2:SDexcludeXG272UTiSiXG305X1 1.0337e-24
C_4_22 WLL iQ2:SDexcludeXG279UTiSiXG306X1 5.3179e-25
C_4_23 WLL iQ2:SDexcludeXG280UTiSiXG306X1 4.9398e-25
C_4_24 WLL iQ2:SiGeBXG294UTiSiXG305X1 9.1602e-26
C_4_25 WLL iQ2:SiGeBXG296UTiSiXG305X1 1.3505e-27
C_4_26 WLL iQ2:SiGeBXG336UTiSiXG305X1 1.2542e-27
C_4_27 WLL iQ2:SiliconNXG311UTiSiXG306X1 6.5596e-26
C_4_28 WLL iQ2:n1g 1.5988e-24
C_4_29 WLL iQ2:n3d 1.0732e-24
C_4_30 WLL iQ2:n4s 1.0732e-24
C_4_31 WLL iQ2:p1g 1.8983e-24
C_4_32 WLL iQ2:p2s 1.1228e-24
C_4_33 WLR iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 3.3974e-22
C_4_34 WLR iQ1:LM00Cobalt2XG314USiGeBXG291X1 6.9332e-23
C_4_35 WLR iQ1:LM00Cobalt2XG314UTiSiXG301X1 6.9249e-23
C_4_36 WLR iQ1:LM00Cobalt2XG314UTiSiXG302X1 6.9244e-23
C_4_37 WLR iQ1:SDexcludeXG271UTiSiXG302X1 1.0536e-24
C_4_38 WLR iQ1:SDexcludeXG277UTiSiXG301X1 5.0099e-25
C_4_39 WLR iQ1:SDexcludeXG278UTiSiXG301X1 5.1682e-25
C_4_40 WLR iQ1:SiGeBXG291UTiSiXG302X1 9.0696e-26
C_4_41 WLR iQ1:SiGeBXG292UTiSiXG302X1 1.1529e-27
C_4_42 WLR iQ1:SiGeBXG331UTiSiXG302X1 1.0466e-27
C_4_43 WLR iQ1:SiGeBXG335UTiSiXG302X1 1.0462e-27
C_4_44 WLR iQ1:SiliconNXG308UTiSiXG301X1 6.4711e-26
C_4_45 WLR iQ1:n1d 1.0653e-24
C_4_46 WLR iQ1:n2s 1.0653e-24
C_4_47 WLR iQ1:n4g 1.7571e-24
C_4_48 WLR iQ1:p1d 1.1422e-24
C_4_49 WLR iQ1:p2g 1.7907e-24
C_4_50 WLR iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 3.4487e-22
C_4_51 WLR iQ2:LM00Cobalt2XG151USiGeBXG294X1 6.9612e-23
C_4_52 WLR iQ2:LM00Cobalt2XG151UTiSiXG305X1 6.9523e-23
C_4_53 WLR iQ2:LM00Cobalt2XG151UTiSiXG306X1 6.9528e-23
C_4_54 WLR iQ2:SDexcludeXG272UTiSiXG305X1 1.0337e-24
C_4_55 WLR iQ2:SDexcludeXG279UTiSiXG306X1 5.3179e-25
C_4_56 WLR iQ2:SDexcludeXG280UTiSiXG306X1 4.9398e-25
C_4_57 WLR iQ2:SiGeBXG294UTiSiXG305X1 9.1602e-26
C_4_58 WLR iQ2:SiGeBXG296UTiSiXG305X1 1.3505e-27
C_4_59 WLR iQ2:SiGeBXG336UTiSiXG305X1 1.2542e-27
C_4_60 WLR iQ2:SiliconNXG311UTiSiXG306X1 6.5596e-26
C_4_61 WLR iQ2:n1g 1.5988e-24
C_4_62 WLR iQ2:n3d 1.0732e-24
C_4_63 WLR iQ2:n4s 1.0732e-24
C_4_64 WLR iQ2:p1g 1.8983e-24
C_4_65 WLR iQ2:p2s 1.1228e-24
C_4_66 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 6.4350e-19
C_4_67 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 4.3378e-22
C_4_68 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 6.6444e-23
C_4_69 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 6.5492e-23
C_4_70 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:SDexcludeXG271UTiSiXG302X1 1.3914e-20
C_4_71 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:SDexcludeXG277UTiSiXG301X1 5.4394e-21
C_4_72 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:SDexcludeXG278UTiSiXG301X1 5.9177e-21
C_4_73 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:SiGeBXG291UTiSiXG302X1 3.6838e-22
C_4_74 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:SiGeBXG292UTiSiXG302X1 6.5387e-26
C_4_75 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:SiGeBXG331UTiSiXG302X1 5.7372e-26
C_4_76 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:SiGeBXG335UTiSiXG302X1 4.7249e-26
C_4_77 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:SiliconNXG308UTiSiXG301X1 3.2450e-22
C_4_78 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:n1d 1.1679e-20
C_4_79 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:n2s 1.1679e-20
C_4_80 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:n4g 1.5238e-19
C_4_81 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:p1d 1.4283e-20
C_4_82 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ1:p2g 2.7108e-20
C_4_83 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 4.4303e-18
C_4_84 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 1.8079e-18
C_4_85 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 1.7328e-18
C_4_86 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 1.8657e-18
C_4_87 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:SDexcludeXG272UTiSiXG305X1 1.0165e-19
C_4_88 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:SDexcludeXG279UTiSiXG306X1 5.9422e-19
C_4_89 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:SDexcludeXG280UTiSiXG306X1 6.9102e-19
C_4_90 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:SiGeBXG294UTiSiXG305X1 7.5709e-20
C_4_91 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:SiGeBXG296UTiSiXG305X1 2.8074e-22
C_4_92 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:SiGeBXG336UTiSiXG305X1 2.8071e-22
C_4_93 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:SiliconNXG311UTiSiXG306X1 1.0974e-18
C_4_94 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:n1g 1.3838e-20
C_4_95 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:n3d 1.9831e-18
C_4_96 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:n4s 1.9831e-18
C_4_97 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:p1g 1.1854e-20
C_4_98 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 iQ2:p2s 1.7680e-19
C_4_99 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 4.3219e-20
C_4_100 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.7937e-24
C_4_101 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 1.1103e-24
C_4_102 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 1.1087e-24
C_4_103 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:SDexcludeXG271UTiSiXG302X1 2.7162e-23
C_4_104 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:SDexcludeXG277UTiSiXG301X1 1.1426e-23
C_4_105 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:SDexcludeXG278UTiSiXG301X1 1.2385e-23
C_4_106 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:SiGeBXG291UTiSiXG302X1 6.8604e-25
C_4_107 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:SiGeBXG292UTiSiXG302X1 9.0240e-28
C_4_108 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:SiGeBXG331UTiSiXG302X1 5.8831e-28
C_4_109 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:SiGeBXG335UTiSiXG302X1 5.4879e-28
C_4_110 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:SiliconNXG308UTiSiXG301X1 6.7612e-25
C_4_111 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:n1d 2.4481e-23
C_4_112 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:n2s 2.4481e-23
C_4_113 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:n4g 4.0956e-22
C_4_114 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:p1d 2.7847e-23
C_4_115 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ1:p2g 2.2527e-23
C_4_116 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.5095e-19
C_4_117 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.4887e-19
C_4_118 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.4887e-19
C_4_119 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.4928e-19
C_4_120 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:SDexcludeXG272UTiSiXG305X1 4.4405e-23
C_4_121 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:SDexcludeXG279UTiSiXG306X1 4.5627e-22
C_4_122 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:SDexcludeXG280UTiSiXG306X1 5.7276e-22
C_4_123 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:SiGeBXG294UTiSiXG305X1 2.1547e-24
C_4_124 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:SiGeBXG296UTiSiXG305X1 1.3214e-26
C_4_125 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:SiGeBXG336UTiSiXG305X1 1.1221e-26
C_4_126 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:SiliconNXG311UTiSiXG306X1 1.3821e-21
C_4_127 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:n1g 3.0017e-23
C_4_128 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:n3d 1.1730e-21
C_4_129 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:n4s 1.1730e-21
C_4_130 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:p1g 3.0256e-23
C_4_131 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 iQ2:p2s 4.6537e-23
C_4_132 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 4.4890e-18
C_4_133 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.8755e-18
C_4_134 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 1.9387e-18
C_4_135 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 1.8009e-18
C_4_136 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:SDexcludeXG271UTiSiXG302X1 1.0257e-19
C_4_137 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:SDexcludeXG277UTiSiXG301X1 6.9639e-19
C_4_138 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:SDexcludeXG278UTiSiXG301X1 5.9957e-19
C_4_139 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:SiGeBXG291UTiSiXG302X1 7.5175e-20
C_4_140 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:SiGeBXG292UTiSiXG302X1 2.6083e-22
C_4_141 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:SiGeBXG331UTiSiXG302X1 2.6084e-22
C_4_142 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:SiGeBXG335UTiSiXG302X1 2.6083e-22
C_4_143 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:SiliconNXG308UTiSiXG301X1 1.0576e-18
C_4_144 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:n1d 1.9393e-18
C_4_145 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:n2s 1.9393e-18
C_4_146 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:n4g 1.3833e-20
C_4_147 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:p1d 1.7722e-19
C_4_148 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ1:p2g 1.1875e-20
C_4_149 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 6.2533e-19
C_4_150 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 4.3620e-22
C_4_151 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 6.7226e-23
C_4_152 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 6.7839e-23
C_4_153 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:SDexcludeXG272UTiSiXG305X1 1.3892e-20
C_4_154 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:SDexcludeXG279UTiSiXG306X1 5.9196e-21
C_4_155 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:SDexcludeXG280UTiSiXG306X1 5.4406e-21
C_4_156 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:SiGeBXG294UTiSiXG305X1 3.6906e-22
C_4_157 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:SiGeBXG296UTiSiXG305X1 6.6788e-26
C_4_158 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:SiGeBXG336UTiSiXG305X1 4.6915e-26
C_4_159 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:SiliconNXG311UTiSiXG306X1 3.2203e-22
C_4_160 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:n1g 1.5121e-19
C_4_161 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:n3d 1.1680e-20
C_4_162 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:n4s 1.1680e-20
C_4_163 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:p1g 2.6955e-20
C_4_164 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 iQ2:p2s 1.4261e-20
C_4_165 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 2.7969e-19
C_4_166 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.7798e-19
C_4_167 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.7824e-19
C_4_168 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.7798e-19
C_4_169 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:SDexcludeXG271UTiSiXG302X1 4.0281e-23
C_4_170 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:SDexcludeXG277UTiSiXG301X1 3.9314e-22
C_4_171 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:SDexcludeXG278UTiSiXG301X1 2.9448e-22
C_4_172 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:SiGeBXG291UTiSiXG302X1 1.8512e-24
C_4_173 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:SiGeBXG292UTiSiXG302X1 1.4201e-26
C_4_174 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:SiGeBXG331UTiSiXG302X1 1.2057e-26
C_4_175 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:SiGeBXG335UTiSiXG302X1 1.2023e-26
C_4_176 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:SiliconNXG308UTiSiXG301X1 7.0098e-22
C_4_177 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:n1d 6.2501e-22
C_4_178 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:n2s 6.2501e-22
C_4_179 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:n4g 2.7371e-23
C_4_180 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:p1d 4.2108e-23
C_4_181 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ1:p2g 2.6845e-23
C_4_182 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 5.0988e-20
C_4_183 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 1.5397e-24
C_4_184 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 9.1116e-25
C_4_185 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 9.1207e-25
C_4_186 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:SDexcludeXG272UTiSiXG305X1 2.4630e-23
C_4_187 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.1274e-23
C_4_188 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.0402e-23
C_4_189 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:SiGeBXG294UTiSiXG305X1 6.2965e-25
C_4_190 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:SiGeBXG296UTiSiXG305X1 1.1357e-27
C_4_191 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:SiGeBXG336UTiSiXG305X1 5.3870e-28
C_4_192 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:SiliconNXG311UTiSiXG306X1 6.1466e-25
C_4_193 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:n1g 3.5252e-22
C_4_194 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:n3d 2.2287e-23
C_4_195 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:n4s 2.2287e-23
C_4_196 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:p1g 2.0448e-23
C_4_197 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 iQ2:p2s 2.5259e-23
C_4_198 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 5.1366e-22
C_4_199 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.0276e-22
C_4_200 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 1.0261e-22
C_4_201 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 1.0260e-22
C_4_202 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:SDexcludeXG271UTiSiXG302X1 2.3996e-24
C_4_203 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:SDexcludeXG277UTiSiXG301X1 1.9130e-24
C_4_204 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:SDexcludeXG278UTiSiXG301X1 1.6760e-24
C_4_205 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:SiGeBXG291UTiSiXG302X1 1.6430e-25
C_4_206 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:SiGeBXG292UTiSiXG302X1 1.3304e-27
C_4_207 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:SiGeBXG331UTiSiXG302X1 1.1514e-27
C_4_208 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:SiGeBXG335UTiSiXG302X1 1.1501e-27
C_4_209 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:SiliconNXG308UTiSiXG301X1 1.3622e-25
C_4_210 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:n1d 3.7057e-24
C_4_211 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:n2s 3.7057e-24
C_4_212 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:n4g 2.7422e-24
C_4_213 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:p1d 2.5616e-24
C_4_214 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ1:p2g 3.0590e-24
C_4_215 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 3.5240e-22
C_4_216 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 6.9790e-23
C_4_217 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 6.9663e-23
C_4_218 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 6.9667e-23
C_4_219 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:SDexcludeXG272UTiSiXG305X1 1.8618e-24
C_4_220 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:SDexcludeXG279UTiSiXG306X1 9.0971e-25
C_4_221 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:SDexcludeXG280UTiSiXG306X1 8.4512e-25
C_4_222 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:SiGeBXG294UTiSiXG305X1 1.3123e-25
C_4_223 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:SiGeBXG296UTiSiXG305X1 2.0523e-27
C_4_224 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:SiGeBXG336UTiSiXG305X1 1.9261e-27
C_4_225 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:SiliconNXG311UTiSiXG306X1 8.7214e-26
C_4_226 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:n1g 3.3962e-24
C_4_227 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:n3d 1.8237e-24
C_4_228 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:n4s 1.8237e-24
C_4_229 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:p1g 2.5082e-24
C_4_230 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 iQ2:p2s 1.9892e-24
C_4_231 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 8.1994e-20
C_4_232 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 8.1117e-20
C_4_233 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 8.1147e-20
C_4_234 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 8.1116e-20
C_4_235 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:SDexcludeXG271UTiSiXG302X1 1.2367e-23
C_4_236 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:SDexcludeXG277UTiSiXG301X1 5.5288e-23
C_4_237 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:SDexcludeXG278UTiSiXG301X1 4.3017e-23
C_4_238 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:SiGeBXG291UTiSiXG302X1 6.6940e-25
C_4_239 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:SiGeBXG292UTiSiXG302X1 5.4400e-27
C_4_240 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:SiGeBXG331UTiSiXG302X1 4.6460e-27
C_4_241 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:SiGeBXG335UTiSiXG302X1 4.6367e-27
C_4_242 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:SiliconNXG308UTiSiXG301X1 1.0034e-22
C_4_243 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:n1d 1.0440e-22
C_4_244 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:n2s 1.0440e-22
C_4_245 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:n4g 8.5069e-24
C_4_246 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:p1d 1.3027e-23
C_4_247 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ1:p2g 9.6993e-24
C_4_248 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 4.0929e-20
C_4_249 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 9.0999e-25
C_4_250 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 6.9333e-25
C_4_251 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 6.9295e-25
C_4_252 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:SDexcludeXG272UTiSiXG305X1 7.5102e-24
C_4_253 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:SDexcludeXG279UTiSiXG306X1 3.3786e-24
C_4_254 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:SDexcludeXG280UTiSiXG306X1 3.1015e-24
C_4_255 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:SiGeBXG294UTiSiXG305X1 2.1862e-25
C_4_256 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:SiGeBXG296UTiSiXG305X1 1.2277e-27
C_4_257 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:SiGeBXG336UTiSiXG305X1 9.8229e-28
C_4_258 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:SiliconNXG311UTiSiXG306X1 1.8676e-25
C_4_259 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:n1g 1.8263e-22
C_4_260 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:n3d 6.6651e-24
C_4_261 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:n4s 6.6651e-24
C_4_262 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:p1g 6.0794e-24
C_4_263 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 iQ2:p2s 7.7268e-24
C_4_264 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 3.4318e-22
C_4_265 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 6.9400e-23
C_4_266 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 6.9310e-23
C_4_267 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 6.9305e-23
C_4_268 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:SDexcludeXG271UTiSiXG302X1 1.2841e-24
C_4_269 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:SDexcludeXG277UTiSiXG301X1 5.8048e-25
C_4_270 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:SDexcludeXG278UTiSiXG301X1 6.0705e-25
C_4_271 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:SiGeBXG291UTiSiXG302X1 9.6889e-26
C_4_272 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:SiGeBXG292UTiSiXG302X1 1.2033e-27
C_4_273 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:SiGeBXG331UTiSiXG302X1 1.0730e-27
C_4_274 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:SiGeBXG335UTiSiXG302X1 1.0723e-27
C_4_275 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:SiliconNXG308UTiSiXG301X1 6.9416e-26
C_4_276 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:n1d 1.2397e-24
C_4_277 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:n2s 1.2397e-24
C_4_278 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:n4g 2.2882e-24
C_4_279 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:p1d 1.3789e-24
C_4_280 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ1:p2g 1.9683e-24
C_4_281 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 4.2152e-22
C_4_282 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 8.4465e-23
C_4_283 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 8.4344e-23
C_4_284 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 8.4352e-23
C_4_285 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:SDexcludeXG272UTiSiXG305X1 1.4579e-24
C_4_286 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:SDexcludeXG279UTiSiXG306X1 8.9909e-25
C_4_287 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:SDexcludeXG280UTiSiXG306X1 9.3213e-25
C_4_288 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:SiGeBXG294UTiSiXG305X1 1.2380e-25
C_4_289 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:SiGeBXG296UTiSiXG305X1 1.5922e-27
C_4_290 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:SiGeBXG336UTiSiXG305X1 1.4598e-27
C_4_291 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:SiliconNXG311UTiSiXG306X1 1.0286e-25
C_4_292 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:n1g 1.8375e-24
C_4_293 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:n3d 1.9070e-24
C_4_294 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:n4s 1.9070e-24
C_4_295 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:p1g 2.3222e-24
C_4_296 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 iQ2:p2s 1.5788e-24
C_4_297 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 2.8560e-20
C_4_298 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.0909e-24
C_4_299 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 8.3359e-25
C_4_300 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 8.3321e-25
C_4_301 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:SDexcludeXG271UTiSiXG302X1 1.0035e-23
C_4_302 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:SDexcludeXG277UTiSiXG301X1 4.1142e-24
C_4_303 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:SDexcludeXG278UTiSiXG301X1 4.4853e-24
C_4_304 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:SiGeBXG291UTiSiXG302X1 2.5847e-25
C_4_305 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:SiGeBXG292UTiSiXG302X1 5.4966e-28
C_4_306 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:SiGeBXG331UTiSiXG302X1 4.0632e-28
C_4_307 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:SiGeBXG335UTiSiXG302X1 3.9293e-28
C_4_308 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:SiliconNXG308UTiSiXG301X1 2.4521e-25
C_4_309 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:n1d 8.8425e-24
C_4_310 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:n2s 8.8425e-24
C_4_311 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:n4g 1.5762e-22
C_4_312 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:p1d 1.0293e-23
C_4_313 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ1:p2g 8.1236e-24
C_4_314 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 6.8590e-20
C_4_315 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 6.7387e-20
C_4_316 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 6.7386e-20
C_4_317 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 6.7426e-20
C_4_318 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:SDexcludeXG272UTiSiXG305X1 1.6601e-23
C_4_319 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:SDexcludeXG279UTiSiXG306X1 5.4806e-23
C_4_320 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:SDexcludeXG280UTiSiXG306X1 6.7941e-23
C_4_321 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:SiGeBXG294UTiSiXG305X1 9.5059e-25
C_4_322 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:SiGeBXG296UTiSiXG305X1 6.4574e-27
C_4_323 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:SiGeBXG336UTiSiXG305X1 5.7341e-27
C_4_324 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:SiliconNXG311UTiSiXG306X1 1.4942e-22
C_4_325 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:n1g 1.1116e-23
C_4_326 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:n3d 1.5374e-22
C_4_327 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:n4s 1.5374e-22
C_4_328 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:p1g 1.2998e-23
C_4_329 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 iQ2:p2s 1.7540e-23
C_4_330 WL:n2g iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 3.9599e-19
C_4_331 WL:n2g iQ1:LM00Cobalt2XG314USiGeBXG291X1 1.6341e-19
C_4_332 WL:n2g iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.8716e-19
C_4_333 WL:n2g iQ1:LM00Cobalt2XG314UTiSiXG302X1 1.6342e-19
C_4_334 WL:n2g iQ1:SDexcludeXG271UTiSiXG302X1 1.1042e-23
C_4_335 WL:n2g iQ1:SDexcludeXG277UTiSiXG301X1 1.2375e-19
C_4_336 WL:n2g iQ1:SDexcludeXG278UTiSiXG301X1 1.2375e-19
C_4_337 WL:n2g iQ1:SiGeBXG291UTiSiXG302X1 1.1042e-23
C_4_338 WL:n2g iQ1:SiGeBXG292UTiSiXG302X1 1.1042e-23
C_4_339 WL:n2g iQ1:SiGeBXG331UTiSiXG302X1 1.1042e-23
C_4_340 WL:n2g iQ1:SiGeBXG335UTiSiXG302X1 1.1042e-23
C_4_341 WL:n2g iQ1:SiliconNXG308UTiSiXG301X1 1.2375e-19
C_4_342 WL:n2g iQ1:n4g 9.1682e-21
C_4_343 WL:n2g iQ1:p2g 6.8534e-21
C_4_344 WL:n2g iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.8095e-19
C_4_345 WL:n2g iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.4021e-23
C_4_346 WL:n2g iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.4036e-23
C_4_347 WL:n2g iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.4459e-23
C_4_348 WL:n2g iQ2:SDexcludeXG272UTiSiXG305X1 1.4769e-26
C_4_349 WL:n2g iQ2:SDexcludeXG279UTiSiXG306X1 4.3842e-25
C_4_350 WL:n2g iQ2:SDexcludeXG280UTiSiXG306X1 4.3842e-25
C_4_351 WL:n2g iQ2:SiGeBXG294UTiSiXG305X1 1.4769e-26
C_4_352 WL:n2g iQ2:SiGeBXG296UTiSiXG305X1 1.4769e-26
C_4_353 WL:n2g iQ2:SiGeBXG336UTiSiXG305X1 1.4769e-26
C_4_354 WL:n2g iQ2:SiliconNXG311UTiSiXG306X1 4.3842e-25
C_4_355 WL:n2g iQ2:n1g 7.7689e-20
C_4_356 WL:n2g iQ2:p1g 1.2027e-20
C_4_357 WL:n3g iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 1.8148e-19
C_4_358 WL:n3g iQ1:LM00Cobalt2XG314USiGeBXG291X1 2.1836e-23
C_4_359 WL:n3g iQ1:LM00Cobalt2XG314UTiSiXG301X1 2.2502e-23
C_4_360 WL:n3g iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.1854e-23
C_4_361 WL:n3g iQ1:SDexcludeXG271UTiSiXG302X1 1.7695e-26
C_4_362 WL:n3g iQ1:SDexcludeXG277UTiSiXG301X1 6.6623e-25
C_4_363 WL:n3g iQ1:SDexcludeXG278UTiSiXG301X1 6.6623e-25
C_4_364 WL:n3g iQ1:SiGeBXG291UTiSiXG302X1 1.7695e-26
C_4_365 WL:n3g iQ1:SiGeBXG292UTiSiXG302X1 1.7695e-26
C_4_366 WL:n3g iQ1:SiGeBXG331UTiSiXG302X1 1.7695e-26
C_4_367 WL:n3g iQ1:SiGeBXG335UTiSiXG302X1 1.7695e-26
C_4_368 WL:n3g iQ1:SiliconNXG308UTiSiXG301X1 6.6623e-25
C_4_369 WL:n3g iQ1:n4g 7.7867e-20
C_4_370 WL:n3g iQ1:p2g 1.2129e-20
C_4_371 WL:n3g iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 3.9546e-19
C_4_372 WL:n3g iQ2:LM00Cobalt2XG151USiGeBXG294X1 1.6196e-19
C_4_373 WL:n3g iQ2:LM00Cobalt2XG151UTiSiXG305X1 1.6197e-19
C_4_374 WL:n3g iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.8558e-19
C_4_375 WL:n3g iQ2:SDexcludeXG272UTiSiXG305X1 1.2126e-23
C_4_376 WL:n3g iQ2:SDexcludeXG279UTiSiXG306X1 1.2362e-19
C_4_377 WL:n3g iQ2:SDexcludeXG280UTiSiXG306X1 1.2362e-19
C_4_378 WL:n3g iQ2:SiGeBXG294UTiSiXG305X1 1.2126e-23
C_4_379 WL:n3g iQ2:SiGeBXG296UTiSiXG305X1 1.2126e-23
C_4_380 WL:n3g iQ2:SiGeBXG336UTiSiXG305X1 1.2126e-23
C_4_381 WL:n3g iQ2:SiliconNXG311UTiSiXG306X1 1.2362e-19
C_4_382 WL:n3g iQ2:n1g 9.1778e-21
C_4_383 WL:n3g iQ2:p1g 6.8384e-21
R_4_0 WLL WLR 6.9104e+00
R_4_1 WLL WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 1.6143e+01
R_4_2 WLL WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 3.5442e+02
R_4_3 WLR WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 3.4175e+02
R_4_4 WLR WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 1.6742e+01
R_4_5 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 4.5618e+01
R_4_6 WL:LM00Cobalt2XG102ULM10Tungsten1XG167X1 WL:n3g 3.3972e+01
R_4_7 WL:LM00Cobalt2XG102ULM40Cobalt5XG90X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 5.4221e+01
R_4_8 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 4.5604e+01
R_4_9 WL:LM00Cobalt2XG357ULM10Tungsten1XG375X1 WL:n2g 3.4157e+01
R_4_10 WL:LM00Cobalt2XG357ULM40Cobalt5XG285X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 5.5872e+01
R_4_11 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 WL:LM20Cobalt3XG327ULM40Cobalt5XG285X1 1.2157e+01
R_4_12 WL:LM20Cobalt3XG327ULM30Cobalt4XG122X1 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 1.7528e+04
R_4_13 WL:LM20Cobalt3XG98ULM30Cobalt4XG122X1 WL:LM20Cobalt3XG98ULM40Cobalt5XG90X1 1.2536e+01

*|NET iQ1 1.0642e-04PF
C_5_0 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 6.5957e-18
C_5_1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 3.5431e-18
C_5_2 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.6534e-18
C_5_3 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.7735e-18
C_5_4 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:SDexcludeXG272UTiSiXG305X1 9.6330e-19
C_5_5 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:SDexcludeXG279UTiSiXG306X1 6.7612e-19
C_5_6 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:SDexcludeXG280UTiSiXG306X1 6.4145e-19
C_5_7 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:SiGeBXG294UTiSiXG305X1 9.0997e-19
C_5_8 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:SiGeBXG296UTiSiXG305X1 1.0155e-20
C_5_9 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:SiGeBXG336UTiSiXG305X1 1.0183e-20
C_5_10 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:SiliconNXG311UTiSiXG306X1 1.0938e-18
C_5_11 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:n1g 2.3186e-19
C_5_12 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:n3d 2.0206e-18
C_5_13 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:n4s 2.0206e-18
C_5_14 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:p1g 1.9213e-19
C_5_15 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ2:p2s 1.8530e-18
C_5_16 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 3.5835e-18
C_5_17 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 5.9810e-20
C_5_18 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.1768e-20
C_5_19 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.1645e-20
C_5_20 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:SDexcludeXG272UTiSiXG305X1 5.9410e-21
C_5_21 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.1901e-22
C_5_22 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:SDexcludeXG280UTiSiXG306X1 9.2339e-23
C_5_23 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:SiGeBXG294UTiSiXG305X1 3.8288e-20
C_5_24 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:SiGeBXG296UTiSiXG305X1 1.2299e-22
C_5_25 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:SiGeBXG336UTiSiXG305X1 1.2314e-22
C_5_26 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:SiliconNXG311UTiSiXG306X1 6.8952e-24
C_5_27 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:n1g 1.6106e-19
C_5_28 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:n3d 2.1819e-22
C_5_29 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:n4s 2.1819e-22
C_5_30 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:p1g 8.1883e-20
C_5_31 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ2:p2s 4.3983e-20
C_5_32 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.8158e-18
C_5_33 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.1637e-20
C_5_34 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 1.8907e-20
C_5_35 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 1.8856e-20
C_5_36 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:SDexcludeXG272UTiSiXG305X1 2.4659e-22
C_5_37 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.0681e-23
C_5_38 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:SDexcludeXG280UTiSiXG306X1 9.2450e-24
C_5_39 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:SiGeBXG294UTiSiXG305X1 2.8317e-21
C_5_40 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:SiGeBXG296UTiSiXG305X1 5.1079e-23
C_5_41 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:SiGeBXG336UTiSiXG305X1 5.1154e-23
C_5_42 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:SiliconNXG311UTiSiXG306X1 5.7109e-25
C_5_43 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:n1g 2.8430e-19
C_5_44 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:n3d 2.0473e-23
C_5_45 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:n4s 2.0473e-23
C_5_46 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:p1g 8.1907e-20
C_5_47 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ2:p2s 2.9761e-21
C_5_48 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.6910e-18
C_5_49 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.1735e-20
C_5_50 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 1.8948e-20
C_5_51 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 1.8897e-20
C_5_52 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:SDexcludeXG272UTiSiXG305X1 2.4874e-22
C_5_53 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.0401e-23
C_5_54 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:SDexcludeXG280UTiSiXG306X1 8.9853e-24
C_5_55 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:SiGeBXG294UTiSiXG305X1 2.8897e-21
C_5_56 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:SiGeBXG296UTiSiXG305X1 5.1573e-23
C_5_57 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:SiGeBXG336UTiSiXG305X1 5.1648e-23
C_5_58 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:SiliconNXG311UTiSiXG306X1 5.5818e-25
C_5_59 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:n1g 1.6106e-19
C_5_60 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:n3d 1.9920e-23
C_5_61 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:n4s 1.9920e-23
C_5_62 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:p1g 8.8900e-20
C_5_63 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ2:p2s 3.0353e-21
C_5_64 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 9.6423e-19
C_5_65 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 5.8808e-21
C_5_66 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.4455e-22
C_5_67 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.4160e-22
C_5_68 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:SDexcludeXG272UTiSiXG305X1 3.0126e-20
C_5_69 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:SDexcludeXG279UTiSiXG306X1 4.0484e-21
C_5_70 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:SDexcludeXG280UTiSiXG306X1 3.3114e-21
C_5_71 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:SiGeBXG294UTiSiXG305X1 5.6430e-21
C_5_72 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:SiGeBXG296UTiSiXG305X1 3.4120e-24
C_5_73 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:SiGeBXG336UTiSiXG305X1 3.3876e-24
C_5_74 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:SiliconNXG311UTiSiXG306X1 2.2720e-22
C_5_75 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:n1g 3.2101e-24
C_5_76 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:n3d 7.5858e-21
C_5_77 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:n4s 7.5858e-21
C_5_78 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:p1g 7.0167e-21
C_5_79 iQ1:SDexcludeXG271UTiSiXG302X1 iQ2:p2s 3.5762e-20
C_5_80 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 6.4420e-19
C_5_81 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 9.3502e-23
C_5_82 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 9.9298e-24
C_5_83 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 1.0100e-23
C_5_84 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:SDexcludeXG272UTiSiXG305X1 3.3060e-21
C_5_85 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.5785e-21
C_5_86 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.4747e-21
C_5_87 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:SiGeBXG294UTiSiXG305X1 8.3583e-23
C_5_88 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:SiGeBXG296UTiSiXG305X1 8.4023e-27
C_5_89 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:SiGeBXG336UTiSiXG305X1 6.2563e-27
C_5_90 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:SiliconNXG311UTiSiXG306X1 8.5934e-23
C_5_91 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:n1g 1.2324e-19
C_5_92 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:n3d 3.1385e-21
C_5_93 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:n4s 3.1385e-21
C_5_94 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:p1g 2.3531e-23
C_5_95 iQ1:SDexcludeXG277UTiSiXG301X1 iQ2:p2s 3.3895e-21
C_5_96 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 6.7743e-19
C_5_97 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 1.2028e-22
C_5_98 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 1.1495e-23
C_5_99 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 1.1680e-23
C_5_100 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:SDexcludeXG272UTiSiXG305X1 4.0405e-21
C_5_101 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.7159e-21
C_5_102 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.5782e-21
C_5_103 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:SiGeBXG294UTiSiXG305X1 1.0879e-22
C_5_104 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:SiGeBXG296UTiSiXG305X1 7.9195e-27
C_5_105 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:SiGeBXG336UTiSiXG305X1 7.3726e-27
C_5_106 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:SiliconNXG311UTiSiXG306X1 9.3545e-23
C_5_107 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:n1g 1.2324e-19
C_5_108 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:n3d 3.3871e-21
C_5_109 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:n4s 3.3871e-21
C_5_110 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:p1g 2.3531e-23
C_5_111 iQ1:SDexcludeXG278UTiSiXG301X1 iQ2:p2s 4.1493e-21
C_5_112 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 9.1055e-19
C_5_113 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 3.8271e-20
C_5_114 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.9010e-21
C_5_115 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.8287e-21
C_5_116 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:SDexcludeXG272UTiSiXG305X1 5.6978e-21
C_5_117 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.0863e-22
C_5_118 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:SDexcludeXG280UTiSiXG306X1 8.3368e-23
C_5_119 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:SiGeBXG294UTiSiXG305X1 3.5514e-20
C_5_120 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:SiGeBXG296UTiSiXG305X1 7.2410e-23
C_5_121 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:SiGeBXG336UTiSiXG305X1 7.2480e-23
C_5_122 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:SiliconNXG311UTiSiXG306X1 6.3380e-24
C_5_123 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:n1g 3.2101e-24
C_5_124 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:n3d 1.9830e-22
C_5_125 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:n4s 1.9830e-22
C_5_126 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:p1g 7.0167e-21
C_5_127 iQ1:SiGeBXG291UTiSiXG302X1 iQ2:p2s 4.1067e-20
C_5_128 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 9.0508e-21
C_5_129 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 9.7883e-23
C_5_130 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 4.0865e-23
C_5_131 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 4.0371e-23
C_5_132 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:SDexcludeXG272UTiSiXG305X1 2.8072e-24
C_5_133 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.0034e-26
C_5_134 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:SDexcludeXG280UTiSiXG306X1 9.2261e-27
C_5_135 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:SiGeBXG294UTiSiXG305X1 5.8007e-23
C_5_136 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:SiGeBXG296UTiSiXG305X1 4.9493e-25
C_5_137 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:SiGeBXG336UTiSiXG305X1 4.9489e-25
C_5_138 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:SiliconNXG311UTiSiXG306X1 9.9510e-28
C_5_139 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:n1g 3.2101e-24
C_5_140 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:n3d 2.0201e-26
C_5_141 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:n4s 2.0201e-26
C_5_142 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:p1g 7.0167e-21
C_5_143 iQ1:SiGeBXG292UTiSiXG302X1 iQ2:p2s 5.9825e-23
C_5_144 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 9.0292e-21
C_5_145 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 9.7860e-23
C_5_146 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 4.0853e-23
C_5_147 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 4.0359e-23
C_5_148 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:SDexcludeXG272UTiSiXG305X1 2.7871e-24
C_5_149 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:SDexcludeXG279UTiSiXG306X1 1.1518e-26
C_5_150 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.1795e-26
C_5_151 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:SiGeBXG294UTiSiXG305X1 5.7994e-23
C_5_152 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:SiGeBXG296UTiSiXG305X1 4.9407e-25
C_5_153 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:SiGeBXG336UTiSiXG305X1 4.9402e-25
C_5_154 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:SiliconNXG311UTiSiXG306X1 5.7818e-28
C_5_155 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:n1g 3.2101e-24
C_5_156 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:n3d 2.3845e-26
C_5_157 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:n4s 2.3845e-26
C_5_158 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:p1g 7.0167e-21
C_5_159 iQ1:SiGeBXG331UTiSiXG302X1 iQ2:p2s 5.9794e-23
C_5_160 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 9.0292e-21
C_5_161 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 9.7859e-23
C_5_162 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 4.0852e-23
C_5_163 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 4.0359e-23
C_5_164 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:SDexcludeXG272UTiSiXG305X1 2.7843e-24
C_5_165 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:SDexcludeXG279UTiSiXG306X1 8.7779e-27
C_5_166 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:SDexcludeXG280UTiSiXG306X1 8.1521e-27
C_5_167 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:SiGeBXG294UTiSiXG305X1 5.7994e-23
C_5_168 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:SiGeBXG296UTiSiXG305X1 4.9407e-25
C_5_169 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:SiGeBXG336UTiSiXG305X1 4.9403e-25
C_5_170 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:SiliconNXG311UTiSiXG306X1 5.1339e-28
C_5_171 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:n1g 3.2101e-24
C_5_172 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:n3d 1.7398e-26
C_5_173 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:n4s 1.7398e-26
C_5_174 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:p1g 7.0167e-21
C_5_175 iQ1:SiGeBXG335UTiSiXG302X1 iQ2:p2s 5.9791e-23
C_5_176 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.0735e-18
C_5_177 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:LM00Cobalt2XG151USiGeBXG294X1 7.0643e-24
C_5_178 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 6.5634e-25
C_5_179 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 6.5958e-25
C_5_180 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:SDexcludeXG272UTiSiXG305X1 2.2895e-22
C_5_181 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:SDexcludeXG279UTiSiXG306X1 9.4296e-23
C_5_182 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:SDexcludeXG280UTiSiXG306X1 8.6593e-23
C_5_183 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:SiGeBXG294UTiSiXG305X1 6.4088e-24
C_5_184 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:SiGeBXG296UTiSiXG305X1 4.7935e-28
C_5_185 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:SiGeBXG336UTiSiXG305X1 4.3580e-28
C_5_186 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:SiliconNXG311UTiSiXG306X1 5.0945e-24
C_5_187 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:n1g 1.2324e-19
C_5_188 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:n3d 1.8597e-22
C_5_189 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:n4s 1.8597e-22
C_5_190 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:p1g 2.3531e-23
C_5_191 iQ1:SiliconNXG308UTiSiXG301X1 iQ2:p2s 2.3536e-22
C_5_192 iQ1:n1d iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.9935e-18
C_5_193 iQ1:n1d iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.2076e-22
C_5_194 iQ1:n1d iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.2047e-23
C_5_195 iQ1:n1d iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.2405e-23
C_5_196 iQ1:n1d iQ2:SDexcludeXG272UTiSiXG305X1 7.5735e-21
C_5_197 iQ1:n1d iQ2:SDexcludeXG279UTiSiXG306X1 3.3878e-21
C_5_198 iQ1:n1d iQ2:SDexcludeXG280UTiSiXG306X1 3.1387e-21
C_5_199 iQ1:n1d iQ2:SiGeBXG294UTiSiXG305X1 1.9874e-22
C_5_200 iQ1:n1d iQ2:SiGeBXG296UTiSiXG305X1 1.6768e-26
C_5_201 iQ1:n1d iQ2:SiGeBXG336UTiSiXG305X1 1.4044e-26
C_5_202 iQ1:n1d iQ2:SiliconNXG311UTiSiXG306X1 1.8453e-22
C_5_203 iQ1:n1d iQ2:n3d 6.7099e-21
C_5_204 iQ1:n1d iQ2:n4s 6.7099e-21
C_5_205 iQ1:n1d iQ2:p2s 7.7722e-21
C_5_206 iQ1:n2s iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.9935e-18
C_5_207 iQ1:n2s iQ2:LM00Cobalt2XG151USiGeBXG294X1 2.2076e-22
C_5_208 iQ1:n2s iQ2:LM00Cobalt2XG151UTiSiXG305X1 2.2047e-23
C_5_209 iQ1:n2s iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.2405e-23
C_5_210 iQ1:n2s iQ2:SDexcludeXG272UTiSiXG305X1 7.5735e-21
C_5_211 iQ1:n2s iQ2:SDexcludeXG279UTiSiXG306X1 3.3878e-21
C_5_212 iQ1:n2s iQ2:SDexcludeXG280UTiSiXG306X1 3.1387e-21
C_5_213 iQ1:n2s iQ2:SiGeBXG294UTiSiXG305X1 1.9874e-22
C_5_214 iQ1:n2s iQ2:SiGeBXG296UTiSiXG305X1 1.6768e-26
C_5_215 iQ1:n2s iQ2:SiGeBXG336UTiSiXG305X1 1.4044e-26
C_5_216 iQ1:n2s iQ2:SiliconNXG311UTiSiXG306X1 1.8453e-22
C_5_217 iQ1:n2s iQ2:n3d 6.7099e-21
C_5_218 iQ1:n2s iQ2:n4s 6.7099e-21
C_5_219 iQ1:n2s iQ2:p2s 7.7722e-21
C_5_220 iQ1:n4g iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 2.2964e-19
C_5_221 iQ1:n4g iQ2:LM00Cobalt2XG151USiGeBXG294X1 1.5877e-19
C_5_222 iQ1:n4g iQ2:LM00Cobalt2XG151UTiSiXG305X1 1.5877e-19
C_5_223 iQ1:n4g iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.8144e-19
C_5_224 iQ1:n4g iQ2:SDexcludeXG272UTiSiXG305X1 3.6073e-24
C_5_225 iQ1:n4g iQ2:SDexcludeXG279UTiSiXG306X1 1.2267e-19
C_5_226 iQ1:n4g iQ2:SDexcludeXG280UTiSiXG306X1 1.2267e-19
C_5_227 iQ1:n4g iQ2:SiGeBXG294UTiSiXG305X1 3.6073e-24
C_5_228 iQ1:n4g iQ2:SiGeBXG296UTiSiXG305X1 3.6073e-24
C_5_229 iQ1:n4g iQ2:SiGeBXG336UTiSiXG305X1 3.6073e-24
C_5_230 iQ1:n4g iQ2:SiliconNXG311UTiSiXG306X1 1.2267e-19
C_5_231 iQ1:n4g iQ2:n1g 8.7799e-21
C_5_232 iQ1:n4g iQ2:p1g 5.6406e-21
C_5_233 iQ1:p1d iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.8567e-18
C_5_234 iQ1:p1d iQ2:LM00Cobalt2XG151USiGeBXG294X1 4.3956e-20
C_5_235 iQ1:p1d iQ2:LM00Cobalt2XG151UTiSiXG305X1 3.0639e-21
C_5_236 iQ1:p1d iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.9896e-21
C_5_237 iQ1:p1d iQ2:SDexcludeXG272UTiSiXG305X1 3.5818e-20
C_5_238 iQ1:p1d iQ2:SDexcludeXG279UTiSiXG306X1 4.1570e-21
C_5_239 iQ1:p1d iQ2:SDexcludeXG280UTiSiXG306X1 3.3948e-21
C_5_240 iQ1:p1d iQ2:SiGeBXG294UTiSiXG305X1 4.1041e-20
C_5_241 iQ1:p1d iQ2:SiGeBXG296UTiSiXG305X1 7.4834e-23
C_5_242 iQ1:p1d iQ2:SiGeBXG336UTiSiXG305X1 7.4880e-23
C_5_243 iQ1:p1d iQ2:SiliconNXG311UTiSiXG306X1 2.3354e-22
C_5_244 iQ1:p1d iQ2:n3d 7.7840e-21
C_5_245 iQ1:p1d iQ2:n4s 7.7840e-21
C_5_246 iQ1:p1d iQ2:p2s 7.6710e-20
C_5_247 iQ1:p2g iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 1.9241e-19
C_5_248 iQ1:p2g iQ2:LM00Cobalt2XG151USiGeBXG294X1 8.1495e-20
C_5_249 iQ1:p2g iQ2:LM00Cobalt2XG151UTiSiXG305X1 8.9090e-20
C_5_250 iQ1:p2g iQ2:LM00Cobalt2XG151UTiSiXG306X1 8.1517e-20
C_5_251 iQ1:p2g iQ2:SDexcludeXG272UTiSiXG305X1 7.5952e-21
C_5_252 iQ1:p2g iQ2:SDexcludeXG279UTiSiXG306X1 2.2559e-23
C_5_253 iQ1:p2g iQ2:SDexcludeXG280UTiSiXG306X1 2.2559e-23
C_5_254 iQ1:p2g iQ2:SiGeBXG294UTiSiXG305X1 7.5952e-21
C_5_255 iQ1:p2g iQ2:SiGeBXG296UTiSiXG305X1 7.5952e-21
C_5_256 iQ1:p2g iQ2:SiGeBXG336UTiSiXG305X1 7.5952e-21
C_5_257 iQ1:p2g iQ2:SiliconNXG311UTiSiXG306X1 2.2559e-23
C_5_258 iQ1:p2g iQ2:n1g 5.6631e-21
C_5_259 iQ1:p2g iQ2:p1g 6.5754e-21
R_5_0 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ1:LM00Cobalt2XG314UTiSiXG301X1 1.2742e+02
R_5_1 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 6.0536e+01
R_5_2 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ1:n4g 1.9988e+03
R_5_3 iQ1:LM00Cobalt2XG314ULM10Tungsten1XG376X1 iQ1:p2g 6.3367e+01
R_5_4 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 0.0000e+00
R_5_5 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ1:SDexcludeXG271UTiSiXG302X1 4.2456e+04
R_5_6 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ1:SiGeBXG291UTiSiXG302X1 0.0000e+00
R_5_7 iQ1:LM00Cobalt2XG314USiGeBXG291X1 iQ1:p1d 2.5492e+03
R_5_8 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ1:LM00Cobalt2XG314UTiSiXG302X1 2.9761e+01
R_5_9 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ1:SDexcludeXG277UTiSiXG301X1 4.3600e+04
R_5_10 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ1:SDexcludeXG278UTiSiXG301X1 4.4689e+04
R_5_11 iQ1:LM00Cobalt2XG314UTiSiXG301X1 iQ1:SiliconNXG308UTiSiXG301X1 8.6430e+01
R_5_12 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ1:SDexcludeXG271UTiSiXG302X1 5.6890e+02
R_5_13 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ1:SiGeBXG291UTiSiXG302X1 0.0000e+00
R_5_14 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ1:SiGeBXG331UTiSiXG302X1 2.2157e+03
R_5_15 iQ1:LM00Cobalt2XG314UTiSiXG302X1 iQ1:SiGeBXG335UTiSiXG302X1 2.1985e+03
R_5_16 iQ1:SDexcludeXG271UTiSiXG302X1 iQ1:SiGeBXG291UTiSiXG302X1 0.0000e+00
R_5_17 iQ1:SDexcludeXG271UTiSiXG302X1 iQ1:SiGeBXG292UTiSiXG302X1 0.0000e+00
R_5_18 iQ1:SDexcludeXG271UTiSiXG302X1 iQ1:SiGeBXG331UTiSiXG302X1 0.0000e+00
R_5_19 iQ1:SDexcludeXG271UTiSiXG302X1 iQ1:SiGeBXG335UTiSiXG302X1 0.0000e+00
R_5_20 iQ1:SDexcludeXG271UTiSiXG302X1 iQ1:p1d 7.3436e+03
R_5_21 iQ1:SDexcludeXG277UTiSiXG301X1 iQ1:SDexcludeXG278UTiSiXG301X1 1.3927e+03
R_5_22 iQ1:SDexcludeXG277UTiSiXG301X1 iQ1:SiliconNXG308UTiSiXG301X1 0.0000e+00
R_5_23 iQ1:SDexcludeXG277UTiSiXG301X1 iQ1:n1d 2.6920e+02
R_5_24 iQ1:SDexcludeXG277UTiSiXG301X1 iQ1:n2s 2.6920e+02
R_5_25 iQ1:SDexcludeXG278UTiSiXG301X1 iQ1:SiliconNXG308UTiSiXG301X1 0.0000e+00
R_5_26 iQ1:SDexcludeXG278UTiSiXG301X1 iQ1:n1d 2.4884e+02
R_5_27 iQ1:SDexcludeXG278UTiSiXG301X1 iQ1:n2s 2.4884e+02
R_5_28 iQ1:SiGeBXG291UTiSiXG302X1 iQ1:SiGeBXG292UTiSiXG302X1 0.0000e+00
R_5_29 iQ1:SiGeBXG291UTiSiXG302X1 iQ1:SiGeBXG331UTiSiXG302X1 0.0000e+00
R_5_30 iQ1:SiGeBXG291UTiSiXG302X1 iQ1:SiGeBXG335UTiSiXG302X1 0.0000e+00
R_5_31 iQ1:SiGeBXG291UTiSiXG302X1 iQ1:p1d 2.4506e+01
R_5_32 iQ1:SiliconNXG308UTiSiXG301X1 iQ1:n1d 3.2049e+01
R_5_33 iQ1:SiliconNXG308UTiSiXG301X1 iQ1:n2s 3.2049e+01
R_5_34 iQ1:n1d iQ1:n2s 0.0000e+00
R_5_35 iQ1:n4g iQ1:p2g 5.6873e+01

*|NET iQ2 1.0605e-04PF
R_6_0 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 6.0529e+01
R_6_1 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 1.2755e+02
R_6_2 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 iQ2:n1g 2.0690e+03
R_6_3 iQ2:LM00Cobalt2XG151ULM10Tungsten1XG149X1 iQ2:p1g 6.2881e+01
R_6_4 iQ2:LM00Cobalt2XG151USiGeBXG294X1 iQ2:LM00Cobalt2XG151UTiSiXG305X1 0.0000e+00
R_6_5 iQ2:LM00Cobalt2XG151USiGeBXG294X1 iQ2:SDexcludeXG272UTiSiXG305X1 3.4182e+04
R_6_6 iQ2:LM00Cobalt2XG151USiGeBXG294X1 iQ2:SiGeBXG294UTiSiXG305X1 0.0000e+00
R_6_7 iQ2:LM00Cobalt2XG151USiGeBXG294X1 iQ2:p2s 1.6653e+03
R_6_8 iQ2:LM00Cobalt2XG151UTiSiXG305X1 iQ2:LM00Cobalt2XG151UTiSiXG306X1 2.9742e+01
R_6_9 iQ2:LM00Cobalt2XG151UTiSiXG305X1 iQ2:SDexcludeXG272UTiSiXG305X1 1.1140e+03
R_6_10 iQ2:LM00Cobalt2XG151UTiSiXG305X1 iQ2:SiGeBXG294UTiSiXG305X1 0.0000e+00
R_6_11 iQ2:LM00Cobalt2XG151UTiSiXG305X1 iQ2:SiGeBXG296UTiSiXG305X1 2.1973e+03
R_6_12 iQ2:LM00Cobalt2XG151UTiSiXG306X1 iQ2:SDexcludeXG279UTiSiXG306X1 4.3520e+04
R_6_13 iQ2:LM00Cobalt2XG151UTiSiXG306X1 iQ2:SDexcludeXG280UTiSiXG306X1 4.5175e+04
R_6_14 iQ2:LM00Cobalt2XG151UTiSiXG306X1 iQ2:SiliconNXG311UTiSiXG306X1 9.1170e+01
R_6_15 iQ2:SDexcludeXG272UTiSiXG305X1 iQ2:SiGeBXG294UTiSiXG305X1 0.0000e+00
R_6_16 iQ2:SDexcludeXG272UTiSiXG305X1 iQ2:SiGeBXG296UTiSiXG305X1 0.0000e+00
R_6_17 iQ2:SDexcludeXG272UTiSiXG305X1 iQ2:SiGeBXG336UTiSiXG305X1 0.0000e+00
R_6_18 iQ2:SDexcludeXG272UTiSiXG305X1 iQ2:p2s 9.9290e+03
R_6_19 iQ2:SDexcludeXG279UTiSiXG306X1 iQ2:SDexcludeXG280UTiSiXG306X1 1.3821e+03
R_6_20 iQ2:SDexcludeXG279UTiSiXG306X1 iQ2:SiliconNXG311UTiSiXG306X1 0.0000e+00
R_6_21 iQ2:SDexcludeXG279UTiSiXG306X1 iQ2:n3d 2.6895e+02
R_6_22 iQ2:SDexcludeXG279UTiSiXG306X1 iQ2:n4s 2.6895e+02
R_6_23 iQ2:SDexcludeXG280UTiSiXG306X1 iQ2:SiliconNXG311UTiSiXG306X1 0.0000e+00
R_6_24 iQ2:SDexcludeXG280UTiSiXG306X1 iQ2:n3d 2.4689e+02
R_6_25 iQ2:SDexcludeXG280UTiSiXG306X1 iQ2:n4s 2.4689e+02
R_6_26 iQ2:SiGeBXG294UTiSiXG305X1 iQ2:SiGeBXG296UTiSiXG305X1 0.0000e+00
R_6_27 iQ2:SiGeBXG294UTiSiXG305X1 iQ2:SiGeBXG336UTiSiXG305X1 0.0000e+00
R_6_28 iQ2:SiGeBXG294UTiSiXG305X1 iQ2:p2s 2.4578e+01
R_6_29 iQ2:SiliconNXG311UTiSiXG306X1 iQ2:n3d 3.2030e+01
R_6_30 iQ2:SiliconNXG311UTiSiXG306X1 iQ2:n4s 3.2030e+01
R_6_31 iQ2:n1g iQ2:p1g 5.6938e+01
R_6_32 iQ2:n3d iQ2:n4s 0.0000e+00

*|INSTANCES
XMP1 iQ1:p1d iQ2:p1g VDD:p1s VBP pmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMP1_delta/(1**0.5)'
XMP2 VDD:p2d iQ1:p2g iQ2:p2s VBP pmos1 l= 0.021u w= 0.005u m= 1 nfin= 1 delvtrand0='XMP2_delta/(1**0.5)'
XMN1 iQ1:n1d iQ2:n1g VSS:n1s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 2 delvtrand0='XMN1_delta/(2**0.5)'
XMN2 BL:n2d WL:n2g iQ1:n2s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 2 delvtrand0='XMN2_delta/(2**0.5)'
XMN3 iQ2:n3d WL:n3g BLB:n3s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 2 delvtrand0='XMN3_delta/(2**0.5)'
XMN4 VSS:n4d iQ1:n4g iQ2:n4s VBN nmos1 l= 0.021u w= 0.005u m= 1 nfin= 2 delvtrand0='XMN4_delta/(2**0.5)'

.ENDS array
